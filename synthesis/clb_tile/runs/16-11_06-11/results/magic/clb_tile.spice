* NGSPICE file created from clb_tile.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 D Q CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_4 abstract view
.subckt sky130_fd_sc_hd__a32o_4 A1 A2 A3 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_4 abstract view
.subckt sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N Y VGND VPWR
.ends

.subckt clb_tile clb_cin clb_cin_south clb_cin_west clb_cout clb_cout_south clb_cout_west
+ clb_input[0] clb_input[10] clb_input[11] clb_input[12] clb_input[13] clb_input[14]
+ clb_input[15] clb_input[16] clb_input[17] clb_input[18] clb_input[19] clb_input[1]
+ clb_input[20] clb_input[21] clb_input[22] clb_input[23] clb_input[24] clb_input[25]
+ clb_input[26] clb_input[27] clb_input[28] clb_input[29] clb_input[2] clb_input[30]
+ clb_input[31] clb_input[3] clb_input[4] clb_input[5] clb_input[6] clb_input[7] clb_input[8]
+ clb_input[9] clb_input_south[0] clb_input_south[10] clb_input_south[11] clb_input_south[12]
+ clb_input_south[13] clb_input_south[14] clb_input_south[15] clb_input_south[16]
+ clb_input_south[17] clb_input_south[18] clb_input_south[19] clb_input_south[1] clb_input_south[20]
+ clb_input_south[21] clb_input_south[22] clb_input_south[23] clb_input_south[24]
+ clb_input_south[25] clb_input_south[26] clb_input_south[27] clb_input_south[28]
+ clb_input_south[29] clb_input_south[2] clb_input_south[30] clb_input_south[31] clb_input_south[3]
+ clb_input_south[4] clb_input_south[5] clb_input_south[6] clb_input_south[7] clb_input_south[8]
+ clb_input_south[9] clb_input_west[0] clb_input_west[10] clb_input_west[11] clb_input_west[12]
+ clb_input_west[13] clb_input_west[14] clb_input_west[15] clb_input_west[16] clb_input_west[17]
+ clb_input_west[18] clb_input_west[19] clb_input_west[1] clb_input_west[20] clb_input_west[21]
+ clb_input_west[22] clb_input_west[23] clb_input_west[24] clb_input_west[25] clb_input_west[26]
+ clb_input_west[27] clb_input_west[28] clb_input_west[29] clb_input_west[2] clb_input_west[30]
+ clb_input_west[31] clb_input_west[3] clb_input_west[4] clb_input_west[5] clb_input_west[6]
+ clb_input_west[7] clb_input_west[8] clb_input_west[9] clb_output[0] clb_output[1]
+ clb_output[2] clb_output[3] clb_output[4] clb_output[5] clb_output[6] clb_output[7]
+ clb_output_south[0] clb_output_south[1] clb_output_south[2] clb_output_south[3]
+ clb_output_south[4] clb_output_south[5] clb_output_south[6] clb_output_south[7]
+ clb_output_west[0] clb_output_west[1] clb_output_west[2] clb_output_west[3] clb_output_west[4]
+ clb_output_west[5] clb_output_west[6] clb_output_west[7] clk conf_cin_type0[0] conf_cin_type0[1]
+ conf_cin_type1 conf_hcb[0] conf_hcb[100] conf_hcb[101] conf_hcb[102] conf_hcb[103]
+ conf_hcb[10] conf_hcb[11] conf_hcb[12] conf_hcb[13] conf_hcb[14] conf_hcb[15] conf_hcb[16]
+ conf_hcb[17] conf_hcb[18] conf_hcb[19] conf_hcb[1] conf_hcb[20] conf_hcb[21] conf_hcb[22]
+ conf_hcb[23] conf_hcb[24] conf_hcb[25] conf_hcb[26] conf_hcb[27] conf_hcb[28] conf_hcb[29]
+ conf_hcb[2] conf_hcb[30] conf_hcb[31] conf_hcb[32] conf_hcb[33] conf_hcb[34] conf_hcb[35]
+ conf_hcb[36] conf_hcb[37] conf_hcb[38] conf_hcb[39] conf_hcb[3] conf_hcb[40] conf_hcb[41]
+ conf_hcb[42] conf_hcb[43] conf_hcb[44] conf_hcb[45] conf_hcb[46] conf_hcb[47] conf_hcb[48]
+ conf_hcb[49] conf_hcb[4] conf_hcb[50] conf_hcb[51] conf_hcb[52] conf_hcb[53] conf_hcb[54]
+ conf_hcb[55] conf_hcb[56] conf_hcb[57] conf_hcb[58] conf_hcb[59] conf_hcb[5] conf_hcb[60]
+ conf_hcb[61] conf_hcb[62] conf_hcb[63] conf_hcb[64] conf_hcb[65] conf_hcb[66] conf_hcb[67]
+ conf_hcb[68] conf_hcb[69] conf_hcb[6] conf_hcb[70] conf_hcb[71] conf_hcb[72] conf_hcb[73]
+ conf_hcb[74] conf_hcb[75] conf_hcb[76] conf_hcb[77] conf_hcb[78] conf_hcb[79] conf_hcb[7]
+ conf_hcb[80] conf_hcb[81] conf_hcb[82] conf_hcb[83] conf_hcb[84] conf_hcb[85] conf_hcb[86]
+ conf_hcb[87] conf_hcb[88] conf_hcb[89] conf_hcb[8] conf_hcb[90] conf_hcb[91] conf_hcb[92]
+ conf_hcb[93] conf_hcb[94] conf_hcb[95] conf_hcb[96] conf_hcb[97] conf_hcb[98] conf_hcb[99]
+ conf_hcb[9] conf_io_type0[0] conf_io_type0[10] conf_io_type0[11] conf_io_type0[12]
+ conf_io_type0[13] conf_io_type0[14] conf_io_type0[15] conf_io_type0[16] conf_io_type0[17]
+ conf_io_type0[18] conf_io_type0[19] conf_io_type0[1] conf_io_type0[20] conf_io_type0[21]
+ conf_io_type0[22] conf_io_type0[23] conf_io_type0[24] conf_io_type0[25] conf_io_type0[26]
+ conf_io_type0[27] conf_io_type0[28] conf_io_type0[29] conf_io_type0[2] conf_io_type0[30]
+ conf_io_type0[31] conf_io_type0[32] conf_io_type0[33] conf_io_type0[34] conf_io_type0[35]
+ conf_io_type0[36] conf_io_type0[37] conf_io_type0[38] conf_io_type0[39] conf_io_type0[3]
+ conf_io_type0[40] conf_io_type0[41] conf_io_type0[42] conf_io_type0[43] conf_io_type0[44]
+ conf_io_type0[45] conf_io_type0[46] conf_io_type0[47] conf_io_type0[48] conf_io_type0[49]
+ conf_io_type0[4] conf_io_type0[50] conf_io_type0[51] conf_io_type0[52] conf_io_type0[53]
+ conf_io_type0[54] conf_io_type0[55] conf_io_type0[56] conf_io_type0[57] conf_io_type0[58]
+ conf_io_type0[59] conf_io_type0[5] conf_io_type0[60] conf_io_type0[61] conf_io_type0[62]
+ conf_io_type0[63] conf_io_type0[6] conf_io_type0[7] conf_io_type0[8] conf_io_type0[9]
+ conf_io_type1[0] conf_io_type1[10] conf_io_type1[11] conf_io_type1[12] conf_io_type1[13]
+ conf_io_type1[14] conf_io_type1[15] conf_io_type1[16] conf_io_type1[17] conf_io_type1[18]
+ conf_io_type1[19] conf_io_type1[1] conf_io_type1[20] conf_io_type1[21] conf_io_type1[22]
+ conf_io_type1[23] conf_io_type1[24] conf_io_type1[25] conf_io_type1[26] conf_io_type1[27]
+ conf_io_type1[28] conf_io_type1[29] conf_io_type1[2] conf_io_type1[30] conf_io_type1[31]
+ conf_io_type1[3] conf_io_type1[4] conf_io_type1[5] conf_io_type1[6] conf_io_type1[7]
+ conf_io_type1[8] conf_io_type1[9] conf_sb[0] conf_sb[10] conf_sb[11] conf_sb[12]
+ conf_sb[13] conf_sb[14] conf_sb[15] conf_sb[16] conf_sb[17] conf_sb[18] conf_sb[19]
+ conf_sb[1] conf_sb[20] conf_sb[21] conf_sb[22] conf_sb[23] conf_sb[24] conf_sb[25]
+ conf_sb[26] conf_sb[27] conf_sb[28] conf_sb[29] conf_sb[2] conf_sb[30] conf_sb[31]
+ conf_sb[32] conf_sb[33] conf_sb[34] conf_sb[35] conf_sb[36] conf_sb[37] conf_sb[38]
+ conf_sb[39] conf_sb[3] conf_sb[40] conf_sb[41] conf_sb[42] conf_sb[43] conf_sb[44]
+ conf_sb[45] conf_sb[46] conf_sb[47] conf_sb[4] conf_sb[5] conf_sb[6] conf_sb[7]
+ conf_sb[8] conf_sb[9] conf_vcb[0] conf_vcb[100] conf_vcb[101] conf_vcb[102] conf_vcb[103]
+ conf_vcb[10] conf_vcb[11] conf_vcb[12] conf_vcb[13] conf_vcb[14] conf_vcb[15] conf_vcb[16]
+ conf_vcb[17] conf_vcb[18] conf_vcb[19] conf_vcb[1] conf_vcb[20] conf_vcb[21] conf_vcb[22]
+ conf_vcb[23] conf_vcb[24] conf_vcb[25] conf_vcb[26] conf_vcb[27] conf_vcb[28] conf_vcb[29]
+ conf_vcb[2] conf_vcb[30] conf_vcb[31] conf_vcb[32] conf_vcb[33] conf_vcb[34] conf_vcb[35]
+ conf_vcb[36] conf_vcb[37] conf_vcb[38] conf_vcb[39] conf_vcb[3] conf_vcb[40] conf_vcb[41]
+ conf_vcb[42] conf_vcb[43] conf_vcb[44] conf_vcb[45] conf_vcb[46] conf_vcb[47] conf_vcb[48]
+ conf_vcb[49] conf_vcb[4] conf_vcb[50] conf_vcb[51] conf_vcb[52] conf_vcb[53] conf_vcb[54]
+ conf_vcb[55] conf_vcb[56] conf_vcb[57] conf_vcb[58] conf_vcb[59] conf_vcb[5] conf_vcb[60]
+ conf_vcb[61] conf_vcb[62] conf_vcb[63] conf_vcb[64] conf_vcb[65] conf_vcb[66] conf_vcb[67]
+ conf_vcb[68] conf_vcb[69] conf_vcb[6] conf_vcb[70] conf_vcb[71] conf_vcb[72] conf_vcb[73]
+ conf_vcb[74] conf_vcb[75] conf_vcb[76] conf_vcb[77] conf_vcb[78] conf_vcb[79] conf_vcb[7]
+ conf_vcb[80] conf_vcb[81] conf_vcb[82] conf_vcb[83] conf_vcb[84] conf_vcb[85] conf_vcb[86]
+ conf_vcb[87] conf_vcb[88] conf_vcb[89] conf_vcb[8] conf_vcb[90] conf_vcb[91] conf_vcb[92]
+ conf_vcb[93] conf_vcb[94] conf_vcb[95] conf_vcb[96] conf_vcb[97] conf_vcb[98] conf_vcb[99]
+ conf_vcb[9] cset east_clb_cin east_clb_cout east_clb_input[0] east_clb_input[10]
+ east_clb_input[11] east_clb_input[12] east_clb_input[13] east_clb_input[14] east_clb_input[15]
+ east_clb_input[16] east_clb_input[17] east_clb_input[18] east_clb_input[19] east_clb_input[1]
+ east_clb_input[20] east_clb_input[21] east_clb_input[22] east_clb_input[23] east_clb_input[24]
+ east_clb_input[25] east_clb_input[26] east_clb_input[27] east_clb_input[28] east_clb_input[29]
+ east_clb_input[2] east_clb_input[30] east_clb_input[31] east_clb_input[3] east_clb_input[4]
+ east_clb_input[5] east_clb_input[6] east_clb_input[7] east_clb_input[8] east_clb_input[9]
+ east_clb_output[0] east_clb_output[1] east_clb_output[2] east_clb_output[3] east_clb_output[4]
+ east_clb_output[5] east_clb_output[6] east_clb_output[7] east_double_in[0] east_double_in[1]
+ east_double_in[2] east_double_in[3] east_double_out[0] east_double_out[1] east_double_out[2]
+ east_double_out[3] east_single_in[0] east_single_in[1] east_single_in[2] east_single_in[3]
+ east_single_out[0] east_single_out[1] east_single_out[2] east_single_out[3] horizontal_global[0]
+ horizontal_global[1] horizontal_global[2] north_clb_cin north_clb_cout north_clb_input[0]
+ north_clb_input[10] north_clb_input[11] north_clb_input[12] north_clb_input[13]
+ north_clb_input[14] north_clb_input[15] north_clb_input[16] north_clb_input[17]
+ north_clb_input[18] north_clb_input[19] north_clb_input[1] north_clb_input[20] north_clb_input[21]
+ north_clb_input[22] north_clb_input[23] north_clb_input[24] north_clb_input[25]
+ north_clb_input[26] north_clb_input[27] north_clb_input[28] north_clb_input[29]
+ north_clb_input[2] north_clb_input[30] north_clb_input[31] north_clb_input[3] north_clb_input[4]
+ north_clb_input[5] north_clb_input[6] north_clb_input[7] north_clb_input[8] north_clb_input[9]
+ north_clb_output[0] north_clb_output[1] north_clb_output[2] north_clb_output[3]
+ north_clb_output[4] north_clb_output[5] north_clb_output[6] north_clb_output[7]
+ north_double_in[0] north_double_in[1] north_double_in[2] north_double_in[3] north_double_out[0]
+ north_double_out[1] north_double_out[2] north_double_out[3] north_single_in[0] north_single_in[1]
+ north_single_in[2] north_single_in[3] north_single_out[0] north_single_out[1] north_single_out[2]
+ north_single_out[3] rst south_double_in[0] south_double_in[1] south_double_in[2]
+ south_double_in[3] south_double_out[0] south_double_out[1] south_double_out[2] south_double_out[3]
+ south_single_in[0] south_single_in[1] south_single_in[2] south_single_in[3] south_single_out[0]
+ south_single_out[1] south_single_out[2] south_single_out[3] vertical_global[0] vertical_global[1]
+ vertical_global[2] west_double_in[0] west_double_in[1] west_double_in[2] west_double_in[3]
+ west_double_out[0] west_double_out[1] west_double_out[2] west_double_out[3] west_single_in[0]
+ west_single_in[1] west_single_in[2] west_single_in[3] west_single_out[0] west_single_out[1]
+ west_single_out[2] west_single_out[3] VPWR VGND
XFILLER_28_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_501 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_726 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_704 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_737 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_428 VGND VPWR sky130_fd_sc_hd__decap_12
X_6914_ _4157_/Y _6914_/B _6972_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_70_718 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_770 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6845_ _6845_/A _6788_/X _6845_/X VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_842 VGND VPWR sky130_fd_sc_hd__decap_12
X_3988_ _3981_/A conf_hcb[47] _3988_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6776_ _6776_/A _6776_/B _6778_/B VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_5727_ _5725_/Y _5726_/X _5728_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_148_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_536 VGND VPWR sky130_fd_sc_hd__decap_8
X_5658_ _5658_/A _5658_/B _5657_/X _5658_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_4609_ _5435_/B _5450_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5589_ _5553_/X _5589_/B _5589_/C _5589_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_7328_ _7343_/A _4465_/X _7295_/A _4456_/X _7328_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_132_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_88 VGND VPWR sky130_fd_sc_hd__decap_12
X_7259_ _4433_/Y _4439_/A _7229_/X _7225_/D _7259_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_77_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_477 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_520 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_661 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_501 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_512 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_483 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_667 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_311 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_366 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_772 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_807 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_309 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_832 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_597 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_865 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_331 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_483 VGND VPWR sky130_fd_sc_hd__decap_4
X_4960_ _4960_/A conf_sb[20] _4960_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3911_ _6343_/D _6359_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_60_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_4891_ _4819_/A _4891_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3842_ _3841_/Y _6228_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_6630_ _6630_/A _6630_/B _6631_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_60_773 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_453 VGND VPWR sky130_fd_sc_hd__decap_4
X_6561_ _6552_/A _6536_/B _6525_/A _6558_/B _6561_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_146_812 VGND VPWR sky130_fd_sc_hd__decap_12
X_3773_ _3760_/A conf_hcb[84] _3773_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5512_ _5466_/X _5468_/X _5498_/Y _5511_/X _5507_/X _5513_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6492_ _6487_/X _6489_/Y _6490_/X _6491_/Y _6492_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_118_536 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_517 VGND VPWR sky130_fd_sc_hd__decap_12
X_5443_ _5441_/X _5443_/B _5444_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_5374_ _5342_/A _5350_/B _5337_/A _5339_/A _5374_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_114_742 VGND VPWR sky130_fd_sc_hd__decap_12
X_7113_ _4255_/X _4261_/X _7119_/B west_double_in[3] _7148_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_4325_ _4249_/A _4344_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_113_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_475 VGND VPWR sky130_fd_sc_hd__decap_12
X_4256_ _4252_/X _4255_/X _4241_/X _4257_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_87_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_147 VGND VPWR sky130_fd_sc_hd__decap_6
X_7044_ _7075_/B _7079_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4187_ _4162_/X _4186_/Y _4182_/X _4187_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_68_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_895 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_707 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_718 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_364 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_526 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_515 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_269 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_559 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6828_ _4107_/X _6786_/X _6782_/X _6828_/D _6828_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XPHY_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_672 VGND VPWR sky130_fd_sc_hd__decap_12
X_6759_ _6759_/A _6720_/B _6721_/A _6497_/D _6759_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XPHY_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_388 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_895 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_491 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_130 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_4110_ _4110_/A conf_hcb[27] _4115_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_78_91 VGND VPWR sky130_fd_sc_hd__fill_1
X_5090_ _7764_/Q _5085_/Y _5089_/X _6663_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4041_ _6644_/C _6670_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_83_106 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_320 VGND VPWR sky130_fd_sc_hd__decap_12
X_5992_ _5991_/X _6008_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_65_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_7731_ _3856_/Y _6191_/B _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_24_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_4943_ _4934_/A conf_sb[24] _4943_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7662_ _4267_/Y _7662_/Q _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6613_ _4013_/Y _6620_/B _6615_/C _6348_/X _6609_/X _6613_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4874_ _4868_/X _4873_/Y _4859_/X _4874_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_60_581 VGND VPWR sky130_fd_sc_hd__decap_12
X_3825_ _3854_/A _3825_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_467 VGND VPWR sky130_fd_sc_hd__decap_12
X_7593_ _4632_/Y _7593_/Q _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_642 VGND VPWR sky130_fd_sc_hd__decap_12
X_6544_ _6606_/A1 _6541_/Y _6543_/Y _6544_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_119_834 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_333 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_12_0_clk clkbuf_3_6_0_clk/X clkbuf_5_25_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_3756_ _3733_/A _3756_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6475_ _6471_/Y _6474_/X _6450_/X _6475_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_119_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_506 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_3687_ _7763_/Q _3687_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5426_ _7256_/D _5571_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_121_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_712 VGND VPWR sky130_fd_sc_hd__decap_12
X_5357_ _5343_/B _5357_/B _5358_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4308_ _4321_/A conf_vcb[96] _4308_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5288_ _5288_/A _5262_/X _5288_/C _5289_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_114_23 VGND VPWR sky130_fd_sc_hd__decap_8
X_4239_ _7074_/B _7078_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_7027_ _7012_/A _7016_/B _6841_/C _6983_/X _7028_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_114_67 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_139 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_802 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_684 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_662 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_898 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_846 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_559 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_762 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_35 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_185 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_358 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_90 psn_inst_psn_buff_90/A psn_inst_psn_buff_90/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_152_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_550 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_380 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_520 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_618 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_821 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_534 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_868 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_548 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_581 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_428 VGND VPWR sky130_fd_sc_hd__fill_2
X_4590_ _4568_/X conf_vcb[43] _4590_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_128_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_133 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_122 VGND VPWR sky130_fd_sc_hd__decap_8
X_6260_ _6260_/A _6261_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_336 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_1_0_clk clkbuf_3_1_0_clk/A clkbuf_4_3_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_50_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6191_ _7732_/Q _6191_/B _3835_/A _3841_/Y _6191_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_131_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_306 VGND VPWR sky130_fd_sc_hd__decap_8
X_5211_ _5211_/A _7644_/Q _7643_/Q _5211_/D _5211_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_97_743 VGND VPWR sky130_fd_sc_hd__decap_12
X_5142_ _5142_/A north_clb_output[1] _5142_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_85_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_798 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_297 VGND VPWR sky130_fd_sc_hd__decap_3
X_5073_ _5075_/C south_double_in[0] _4294_/Y _5073_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_69_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_128 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_117 VGND VPWR sky130_fd_sc_hd__decap_4
X_4024_ _6582_/A _6614_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_84_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_470 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_548 VGND VPWR sky130_fd_sc_hd__fill_1
X_5975_ _5975_/A _5976_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_40_507 VGND VPWR sky130_fd_sc_hd__fill_1
X_7714_ _7714_/D _7714_/Q _7713_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4926_ _4925_/X _4926_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_138_406 VGND VPWR sky130_fd_sc_hd__fill_2
X_4857_ _4844_/A conf_sb[42] _4857_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7645_ _4347_/Y _7645_/Q _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_620 VGND VPWR sky130_fd_sc_hd__decap_8
X_3808_ _6148_/A _6129_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7576_ _7576_/D _7576_/Q _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6527_ _6558_/B _6536_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4788_ _3804_/A _4843_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3739_ _3733_/X _3738_/Y _3724_/X _3739_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6458_ horizontal_global[2] _6458_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_134_678 VGND VPWR sky130_fd_sc_hd__decap_12
X_6389_ _6389_/A _6428_/B _6389_/C _6389_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_122_818 VGND VPWR sky130_fd_sc_hd__decap_6
X_5409_ _5408_/X _5409_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_0_614 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_776 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_843 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_470 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_131 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_367 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_164 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_570 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_406 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_776 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_486 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_188 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_905 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_286 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_779 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_245 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_70 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_481 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_153 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_868 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_5760_ _5753_/X _5760_/B _5810_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_43_890 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_91 VGND VPWR sky130_fd_sc_hd__decap_12
X_4711_ _4708_/X _5711_/D _4698_/X _4712_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5691_ _5691_/A _5715_/B _5681_/A _5681_/B _5720_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_147_203 VGND VPWR sky130_fd_sc_hd__fill_1
X_7430_ _7430_/HI clb_output_west[6] VGND VPWR sky130_fd_sc_hd__conb_1
X_4642_ _4725_/A _4642_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_584 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_7361_ _7396_/D _7370_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4573_ _4570_/X _5353_/B _4560_/X _4574_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6312_ _6311_/X _6312_/B _6314_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_7292_ _7292_/A _7299_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6243_ _6218_/C _6232_/B _6243_/C _6202_/A _6244_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_116_678 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_659 VGND VPWR sky130_fd_sc_hd__decap_12
X_6174_ horizontal_global[0] _6174_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_130_136 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_212 VGND VPWR sky130_fd_sc_hd__fill_2
X_5125_ _5125_/A north_clb_output[1] _5125_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_404 VGND VPWR sky130_fd_sc_hd__decap_3
X_5056_ _5056_/A _7287_/A _5056_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_437 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_4007_ _3982_/X _6583_/A _4002_/X _4008_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_84_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_470 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_68 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_484 VGND VPWR sky130_fd_sc_hd__decap_3
X_5958_ _5956_/X _5958_/B _5958_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_4909_ _3949_/A _4911_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5889_ _5889_/A _5888_/X _5889_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_154_707 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_236 VGND VPWR sky130_fd_sc_hd__fill_2
X_7628_ _4435_/Y _7628_/Q _7628_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_7559_ _4823_/Y _6001_/B _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_4_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_147 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_466 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_383 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_651 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_492 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_259 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_440 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_665 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_389 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_511 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_871 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_588 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_56 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_5 clb_input_west[1] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_805 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_401 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_849 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_337 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_746 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6930_ _6930_/A _6930_/B _6931_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_6861_ _6883_/A _6851_/B _6862_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_35_665 VGND VPWR sky130_fd_sc_hd__decap_6
X_6792_ _6792_/A _6793_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_90_793 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_771 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_484 VGND VPWR sky130_fd_sc_hd__decap_12
X_5812_ _5811_/X _5812_/B _5814_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_23_849 VGND VPWR sky130_fd_sc_hd__decap_4
X_5743_ _5740_/X _5741_/X _7757_/Q _5742_/X _5743_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_31_871 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_556 VGND VPWR sky130_fd_sc_hd__decap_12
X_5674_ _5715_/A _5674_/B _5675_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_129_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_7413_ _7413_/A _7413_/B _7413_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4625_ _7594_/Q _4625_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_135_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_291 VGND VPWR sky130_fd_sc_hd__decap_4
X_7344_ _7342_/Y _7343_/X _7344_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4556_ _4543_/X _4555_/X _4533_/X _4557_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_144_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_412 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_626 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_103 VGND VPWR sky130_fd_sc_hd__fill_2
X_7275_ _7275_/A _7274_/Y _7275_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4487_ _7353_/A _7364_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6226_ _6229_/C _6226_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_104_659 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_489 VGND VPWR sky130_fd_sc_hd__fill_1
X_6157_ _6163_/C _6129_/B _6156_/Y west_double_out[0] _6153_/X _6157_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_106_68 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_810 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_381 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_521 VGND VPWR sky130_fd_sc_hd__decap_12
X_5108_ _5107_/A _5137_/B _5108_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_122_12 VGND VPWR sky130_fd_sc_hd__decap_12
X_6088_ _7552_/Q _4858_/Y north_double_in[0] _6086_/X _6087_/X east_double_out[2]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_122_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_790 VGND VPWR sky130_fd_sc_hd__decap_12
X_5039_ _5039_/A _6058_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_82_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_654 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_893 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_209 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_453 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_442 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_753 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_510 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_692 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_223 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_234 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_554 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_727 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_292 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_170 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_668 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_192 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_718 VGND VPWR sky130_fd_sc_hd__decap_12
X_4410_ _4410_/A _7181_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_8_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_5390_ _7220_/A _5390_/B _5390_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_98_112 VGND VPWR sky130_fd_sc_hd__decap_12
X_4341_ _4272_/A _4341_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4272_ _4272_/A _4272_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7060_ _7058_/Y _7059_/X _7040_/A _7060_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_98_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_6011_ _5993_/A _5978_/A _6008_/A _7201_/D _6011_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_140_297 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_521 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_373 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_598 VGND VPWR sky130_fd_sc_hd__decap_12
X_6913_ _6930_/A _6923_/B _4163_/A _6913_/D _6914_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_35_440 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_782 VGND VPWR sky130_fd_sc_hd__decap_8
X_6844_ _6789_/X _6793_/A _6843_/X _6845_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_23_646 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_410 VGND VPWR sky130_fd_sc_hd__decap_12
X_3987_ _3981_/Y _3986_/X _3987_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6775_ _6774_/Y _6773_/X _6776_/A VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_5726_ _5691_/A _5715_/B _5805_/C _5681_/X _5726_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_148_364 VGND VPWR sky130_fd_sc_hd__decap_12
X_5657_ _5655_/X _5657_/B _5657_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4608_ _5397_/B _5435_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5588_ _5588_/A _5588_/B _5589_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_144_581 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_784 VGND VPWR sky130_fd_sc_hd__decap_8
X_7327_ _7295_/A _4456_/X _7326_/Y _5120_/Y _7323_/X _7327_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4539_ _4513_/X _4538_/X _4533_/X _4540_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_2_528 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_78 VGND VPWR sky130_fd_sc_hd__fill_1
X_7258_ _4422_/X _7232_/X _7241_/X _5859_/X _7255_/X _7258_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_89_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_6209_ _6208_/X _6229_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_297 VGND VPWR sky130_fd_sc_hd__decap_8
X_7189_ _7189_/A _7189_/B _7184_/X _7188_/X _7189_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_93_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_88 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_229 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_657 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_476 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_375 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_459 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_71 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_844 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_546 VGND VPWR sky130_fd_sc_hd__decap_12
X_3910_ _6332_/B _6343_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4890_ _4889_/X conf_sb[35] _4894_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_3841_ _6218_/B _3841_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6560_ _6525_/X _3991_/X _6553_/C _6493_/X _6557_/X _6560_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_80_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_3772_ _3772_/A _3772_/B _7746_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_649 VGND VPWR sky130_fd_sc_hd__decap_8
X_5511_ _5076_/Y _5511_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6491_ _3956_/X _6486_/B _6481_/C _6558_/D _6491_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_9_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_367 VGND VPWR sky130_fd_sc_hd__decap_12
X_5442_ _5414_/C _5414_/D _5433_/Y north_double_out[2] _5439_/X _5443_/B VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_133_529 VGND VPWR sky130_fd_sc_hd__decap_3
X_5373_ _5337_/A _5353_/B _5348_/C south_double_out[2] _5370_/X _5373_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_114_754 VGND VPWR sky130_fd_sc_hd__decap_8
X_7112_ _7111_/X _7153_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4324_ _4324_/A _4323_/X _4324_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_114_798 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_487 VGND VPWR sky130_fd_sc_hd__fill_1
X_7043_ _7043_/A _7075_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4255_ _7132_/A _4255_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4186_ _4186_/A _4186_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_68_874 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_535 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_727 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_855 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_376 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_398 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6827_ east_double_in[1] _6828_/D VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_251 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_6758_ _6722_/A _6769_/B _6758_/C _6758_/D _6758_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_148_172 VGND VPWR sky130_fd_sc_hd__decap_12
X_6689_ _6658_/A _6652_/B _6658_/C _6497_/D _6689_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_109_526 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_5709_ _5709_/A _5709_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_137_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_315 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_765 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_605 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_735 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_107 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_516 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_273 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_631 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_304 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_562 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_584 VGND VPWR sky130_fd_sc_hd__decap_12
X_4040_ _3953_/A _4040_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_77_660 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_332 VGND VPWR sky130_fd_sc_hd__decap_4
X_5991_ _7558_/Q _5991_/B _5991_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_80_825 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_568 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_579 VGND VPWR sky130_fd_sc_hd__decap_8
X_7730_ _7730_/D _7730_/Q _7628_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_91_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_281 VGND VPWR sky130_fd_sc_hd__decap_12
X_4942_ _4942_/A _4942_/B _4942_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7661_ _7661_/D _7661_/Q _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6612_ _6602_/B _6615_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_4873_ _7548_/Q _4873_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_60_593 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_251 VGND VPWR sky130_fd_sc_hd__decap_12
X_3824_ _3823_/X _6179_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_7592_ _4638_/Y _7592_/Q _7592_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6543_ _6541_/Y _6542_/X _6522_/X _6543_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_119_846 VGND VPWR sky130_fd_sc_hd__decap_8
X_3755_ _3760_/A conf_hcb[88] _3755_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_654 VGND VPWR sky130_fd_sc_hd__decap_12
X_6474_ _6448_/B _6472_/X _6473_/X _6467_/X _6474_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_119_879 VGND VPWR sky130_fd_sc_hd__decap_12
X_3686_ _3949_/A _4958_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_134_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_315 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_518 VGND VPWR sky130_fd_sc_hd__fill_1
X_5425_ _5431_/A _5423_/B _5450_/A _5435_/B _5425_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_133_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_5356_ _5351_/A _5370_/B _5355_/X _5356_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_0_807 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_584 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_724 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_223 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_446 VGND VPWR sky130_fd_sc_hd__decap_8
X_4307_ _4303_/Y _4306_/X _7654_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5287_ _5287_/A _5182_/X _5288_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_101_245 VGND VPWR sky130_fd_sc_hd__decap_6
X_7026_ _7026_/A _7026_/B _7028_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_59_148 VGND VPWR sky130_fd_sc_hd__decap_8
X_4238_ _7054_/B _7074_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_101_278 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_671 VGND VPWR sky130_fd_sc_hd__decap_4
X_4169_ _6938_/B _6913_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_55_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_173 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_479 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_468 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_47 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_613 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_367 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_197 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_337 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_91 _7251_/B _7315_/B VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_80 psn_inst_psn_buff_80/A psn_inst_psn_buff_80/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_543 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_405 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_502 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_546 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_321 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_343 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_61 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_700 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_610 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_142 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_849 VGND VPWR sky130_fd_sc_hd__decap_12
X_5210_ _7644_/Q _5206_/X _5207_/X _5208_/X _5209_/X _5210_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_142_145 VGND VPWR sky130_fd_sc_hd__decap_8
X_6190_ _6189_/Y _6190_/B clb_input[7] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_89_91 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_402 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_178 VGND VPWR sky130_fd_sc_hd__decap_8
X_5141_ _4377_/Y _5154_/A clb_output[3] _5141_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_97_733 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_755 VGND VPWR sky130_fd_sc_hd__decap_4
X_5072_ _5072_/A _5137_/B _5072_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_619 VGND VPWR sky130_fd_sc_hd__fill_1
X_4023_ _4017_/A conf_hcb[41] _4023_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_111_587 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_405 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_641 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_814 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_343 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_335 VGND VPWR sky130_fd_sc_hd__fill_1
X_7713_ _7713_/D _7713_/Q _7713_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5974_ _5970_/C _5975_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_100_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4925_ _3681_/X _4925_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7644_ _7644_/D _7644_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4856_ _4856_/A _4855_/X _7552_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_3807_ _3806_/X _6148_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7575_ _7575_/D _7575_/Q _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6526_ _6547_/B _6558_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4787_ _4783_/Y _4787_/B _4787_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_276 VGND VPWR sky130_fd_sc_hd__decap_12
X_3738_ _3738_/A _3738_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6457_ _6470_/A _6456_/X _6457_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_109_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_337 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_156 VGND VPWR sky130_fd_sc_hd__decap_8
X_6388_ _6424_/B _6428_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5408_ _5408_/A _5408_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_142_690 VGND VPWR sky130_fd_sc_hd__decap_12
X_5339_ _5339_/A _5348_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_88_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_254 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_89 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_576 VGND VPWR sky130_fd_sc_hd__decap_4
X_7009_ _7004_/X _7006_/Y _7007_/X _7008_/X _7009_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_855 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_154 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_143 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_418 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_715 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_112 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_736 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_213 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_788 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_276 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_619 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_747 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_438 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_129 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_11_0_clk clkbuf_3_5_0_clk/X clkbuf_5_23_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_81_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_622 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_376 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_132 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_346 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_165 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_541 VGND VPWR sky130_fd_sc_hd__decap_12
X_4710_ _5706_/D _5711_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5690_ _4714_/A _5691_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_148_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_4641_ _4090_/A _4725_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_128_473 VGND VPWR sky130_fd_sc_hd__decap_12
X_7360_ _4482_/A _7396_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4572_ _5362_/B _5353_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6311_ _6310_/Y _6309_/X _6311_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_7291_ _7291_/A _7291_/B _7292_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_7_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_6242_ _6242_/A _6242_/B _6244_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_104_808 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_318 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_690 VGND VPWR sky130_fd_sc_hd__decap_12
X_6173_ _6173_/A _6129_/Y _6172_/X _6173_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_69_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_703 VGND VPWR sky130_fd_sc_hd__fill_1
X_5124_ _7530_/Q _5124_/B east_single_in[2] _5124_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_84_224 VGND VPWR sky130_fd_sc_hd__decap_8
X_5055_ _5055_/A _7287_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4006_ _4006_/A _6583_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_65_482 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_29 VGND VPWR sky130_fd_sc_hd__decap_12
X_5957_ _4804_/X _5659_/X _5916_/X _5910_/A _5958_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_52_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_379 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_496 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_349 VGND VPWR sky130_fd_sc_hd__decap_8
X_4908_ _4908_/A _4908_/B _4908_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7627_ _4441_/Y _7627_/Q _7628_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5888_ _5888_/A _5888_/B _5888_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_119_440 VGND VPWR sky130_fd_sc_hd__decap_8
X_4839_ _4834_/A conf_sb[46] _4842_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_596 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_218 VGND VPWR sky130_fd_sc_hd__decap_3
X_7558_ _7558_/D _7558_/Q _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_270 VGND VPWR sky130_fd_sc_hd__decap_4
X_6509_ horizontal_global[1] _6510_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_4_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_7489_ clb_input_south[6] clb_input[22] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_136_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_679 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_657 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_104 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_552 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_340 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_703 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_395 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_836 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_290 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_379 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_0_0_clk clkbuf_3_1_0_clk/A clkbuf_4_0_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_32_828 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_226 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_91 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_541 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_62 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_883 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_567 VGND VPWR sky130_fd_sc_hd__fill_2
XANTENNA_6 clb_input_west[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_141_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_443 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_817 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_611 VGND VPWR sky130_fd_sc_hd__decap_3
X_6860_ _6881_/A _6860_/B _6908_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_19_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_6791_ _6791_/A _6790_/X _6792_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5811_ _5811_/A _5809_/X _5811_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_34_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_688 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_614 VGND VPWR sky130_fd_sc_hd__decap_8
X_5742_ _7556_/Q _5742_/B south_double_in[3] _5742_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_62_496 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_371 VGND VPWR sky130_fd_sc_hd__decap_8
X_5673_ _5673_/A _5673_/B _5673_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_135_218 VGND VPWR sky130_fd_sc_hd__fill_2
X_7412_ _7284_/A _7412_/B _7413_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4624_ _4512_/X _4624_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7343_ _7343_/A _4466_/X _7215_/C _7299_/B _7343_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4555_ _4554_/X _4555_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_131_424 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_638 VGND VPWR sky130_fd_sc_hd__decap_3
X_7274_ _7234_/A _7234_/B _7241_/X _5881_/X _7244_/X _7274_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_89_327 VGND VPWR sky130_fd_sc_hd__decap_12
X_4486_ _4479_/X conf_vcb[61] _4486_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6225_ _6220_/X _6222_/Y _6223_/X _6224_/X _6225_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_143_295 VGND VPWR sky130_fd_sc_hd__decap_8
X_6156_ _6133_/X _6156_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_58_714 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_703 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_533 VGND VPWR sky130_fd_sc_hd__fill_1
X_5107_ _5107_/A _5138_/B _5107_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6087_ _7551_/Q south_double_in[3] _4854_/Y _6087_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_122_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_5038_ _5033_/A conf_sb[3] _5041_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_122_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_750 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_282 VGND VPWR sky130_fd_sc_hd__fill_1
X_6989_ _7017_/A _6994_/B _7017_/C _6795_/D _7024_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_139_513 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_526 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_721 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_242 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_765 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_736 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_408 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_246 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_514 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_430 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_160 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_193 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_582 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_251 VGND VPWR sky130_fd_sc_hd__fill_1
X_4340_ _5216_/A _5218_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_141_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_4271_ _7101_/B _4271_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_98_124 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_243 VGND VPWR sky130_fd_sc_hd__decap_12
X_6010_ _5990_/A _4831_/A _5976_/A _5993_/B _6010_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_67_533 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_853 VGND VPWR sky130_fd_sc_hd__fill_1
X_6912_ _6912_/A _6910_/X north_clb_input[4] VGND VPWR sky130_fd_sc_hd__nor2_4
X_6843_ _6793_/Y _6843_/B _6843_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_51_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_422 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_433 VGND VPWR sky130_fd_sc_hd__decap_8
X_3986_ _3982_/X _6558_/A _3973_/X _3986_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6774_ _6706_/A _6773_/B _6774_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_5725_ _5725_/A _5724_/X _5725_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_148_376 VGND VPWR sky130_fd_sc_hd__decap_12
X_5656_ _5615_/A _5615_/B _5622_/X _5515_/X _5626_/X _5657_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_30_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_218 VGND VPWR sky130_fd_sc_hd__decap_12
X_4607_ _5406_/B _5397_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_105_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_5587_ _5539_/X _5541_/X _5578_/Y _5511_/X _5584_/X _5588_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_7326_ _7310_/X _7326_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4538_ _4537_/Y _4538_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_284 VGND VPWR sky130_fd_sc_hd__fill_1
X_7257_ _7253_/X _7254_/X _7255_/X _7256_/Y _7257_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_104_435 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_135 VGND VPWR sky130_fd_sc_hd__fill_1
X_4469_ _4463_/A conf_vcb[64] _4469_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6208_ _7732_/Q _3852_/A _6208_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_132_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_265 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_254 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_500 VGND VPWR sky130_fd_sc_hd__decap_12
X_7188_ _7187_/X _7164_/X _7188_/C _7188_/X VGND VPWR sky130_fd_sc_hd__and3_4
X_6139_ west_single_out[1] _6139_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_86_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_216 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_591 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_321 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_335 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_733 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_90 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_691 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_680 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_558 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_377 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_901 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_761 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_772 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_783 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_794 VGND VPWR sky130_fd_sc_hd__decap_8
X_3840_ _3846_/A conf_hcb[72] _3840_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_32_466 VGND VPWR sky130_fd_sc_hd__decap_12
X_3771_ _3756_/X _6098_/A _3770_/X _3772_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_12_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_640 VGND VPWR sky130_fd_sc_hd__decap_12
X_5510_ _5504_/X _5506_/Y _5507_/X _5509_/Y _5513_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_146_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_6490_ _6480_/C _6480_/D _6452_/X _6481_/B _6490_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_73_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_5441_ _5437_/X _5438_/Y _5439_/X _5440_/Y _5441_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_145_379 VGND VPWR sky130_fd_sc_hd__decap_12
X_5372_ _5367_/X _5369_/Y _5370_/X _5371_/Y _5372_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_141_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_530 VGND VPWR sky130_fd_sc_hd__fill_2
X_7111_ _7110_/X _7111_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4323_ _4304_/X _4322_/Y _4318_/X _4323_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_113_243 VGND VPWR sky130_fd_sc_hd__fill_1
X_7042_ _7041_/X _7053_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_4254_ _7127_/A _7132_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4185_ _4161_/A conf_hcb[14] _4188_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_103_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_672 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_525 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_344 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_547 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_878 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_901 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_388 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6826_ _4117_/Y _4123_/X _6821_/C _6785_/X _6826_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_606 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_753 VGND VPWR sky130_fd_sc_hd__decap_8
X_6757_ _6720_/A _6726_/B _6744_/Y _6493_/X _6753_/X _6757_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XPHY_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_477 VGND VPWR sky130_fd_sc_hd__decap_8
X_3969_ _3959_/A conf_hcb[50] _3975_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_109_505 VGND VPWR sky130_fd_sc_hd__fill_1
X_5708_ _5704_/X _5705_/Y _5706_/X _5707_/X _5708_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_149_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_6688_ _6654_/A _6700_/B _6688_/C _6688_/D _6688_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_109_538 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_5639_ _5635_/X _5636_/X _5637_/X _5638_/Y _5639_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_151_327 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_368 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_711 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_145_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_593 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_733 VGND VPWR sky130_fd_sc_hd__decap_8
X_7309_ _7309_/A _7291_/B _7310_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_2_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_777 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_591 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_794 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_915 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_128_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_143 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_379 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_571 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_596 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_202 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_631 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_620 VGND VPWR sky130_fd_sc_hd__decap_8
X_5990_ _5990_/A _5990_/B _5988_/A _5988_/B _6019_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_92_675 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_196 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_794 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_731 VGND VPWR sky130_fd_sc_hd__fill_1
X_4941_ _4926_/X _6047_/A _4940_/X _4942_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_45_580 VGND VPWR sky130_fd_sc_hd__decap_4
X_7660_ _4278_/Y _4276_/A _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4872_ _4872_/A conf_sb[39] _4875_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_17_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_742 VGND VPWR sky130_fd_sc_hd__decap_12
X_6611_ _6607_/X _6608_/X _6609_/X _6610_/Y _6611_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3823_ _6132_/B _3823_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_7591_ _7591_/D _7591_/Q _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6542_ _6520_/B _6472_/X _6473_/X _6538_/A _6542_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_3754_ _3706_/A _3760_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_470 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_121 VGND VPWR sky130_fd_sc_hd__fill_1
X_6473_ _6139_/Y _6473_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3685_ _3702_/A conf_hcb[102] _3691_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5424_ _5423_/A _5427_/B _5433_/A _5197_/X _5396_/B _5424_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_145_198 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_327 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_5355_ _5342_/B _5184_/X _5190_/X _5351_/X _5355_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_0_819 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_596 VGND VPWR sky130_fd_sc_hd__fill_2
X_4306_ _4304_/X _5111_/A _4295_/X _4306_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5286_ _7608_/Q _4554_/X _5285_/X _5288_/C VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_75_609 VGND VPWR sky130_fd_sc_hd__fill_1
X_7025_ _7016_/B _6837_/X _7012_/A _6983_/X _7026_/B VGND VPWR sky130_fd_sc_hd__a211o_4
X_4237_ _7037_/B _7054_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_59_138 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_119 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_801 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_620 VGND VPWR sky130_fd_sc_hd__decap_12
X_4168_ _4161_/A conf_hcb[17] _4168_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_67_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_558 VGND VPWR sky130_fd_sc_hd__decap_8
X_4099_ _4372_/A _4100_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_15_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_185 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_399 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_742 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_764 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6809_ _6145_/Y _6809_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_403 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_611 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_59 VGND VPWR sky130_fd_sc_hd__fill_2
Xpsn_inst_psn_buff_70 _5922_/A _7376_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_92 psn_inst_psn_buff_94/X psn_inst_psn_buff_90/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_635 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_81 _5182_/X psn_inst_psn_buff_79/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_428 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_417 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_672 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_439 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_290 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_837 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_622 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_789 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_522 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_200 VGND VPWR sky130_fd_sc_hd__decap_12
X_5140_ _5136_/X _4369_/Y _5123_/X _5137_/X _5139_/X south_single_out[3] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_36_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_778 VGND VPWR sky130_fd_sc_hd__decap_12
X_5071_ _5072_/A _5138_/B _5071_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_69_458 VGND VPWR sky130_fd_sc_hd__decap_12
X_4022_ _4022_/A _4021_/X _4022_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_84_417 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_333 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_355 VGND VPWR sky130_fd_sc_hd__decap_8
X_5973_ _5973_/A _5980_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_80_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_826 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_388 VGND VPWR sky130_fd_sc_hd__fill_1
X_7712_ _3968_/Y _6448_/A _7713_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_369 VGND VPWR sky130_fd_sc_hd__decap_8
X_4924_ _4934_/A conf_sb[28] _4924_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_100_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_7643_ _4357_/Y _7643_/Q _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4855_ _4845_/X _4854_/Y _4836_/X _4855_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_3806_ _7739_/Q _3806_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4786_ _4762_/X _4785_/X _4780_/X _4787_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7574_ _4739_/Y _4736_/A _7574_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6525_ _6525_/A _6525_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_119_655 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_132 VGND VPWR sky130_fd_sc_hd__decap_8
X_3737_ _3745_/A conf_hcb[92] _3740_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_677 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_817 VGND VPWR sky130_fd_sc_hd__decap_8
X_6456_ _6453_/X _6455_/X _6456_/C _6456_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_119_699 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_349 VGND VPWR sky130_fd_sc_hd__decap_12
X_6387_ _6387_/A _6424_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5407_ _5405_/B _5407_/B _5408_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5338_ _5359_/B _5339_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_288 VGND VPWR sky130_fd_sc_hd__decap_12
X_7008_ _4194_/A _7013_/B _7008_/C _6817_/D _7008_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5269_ _5262_/X _5269_/B _5269_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_18_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_686 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_325 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_870 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_308 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_84 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_341 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_759 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_225 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_409 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_642 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_675 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_100 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_388 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_358 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_369 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_520 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_380 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4640_ _7591_/Q _4640_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_30_553 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_463 VGND VPWR sky130_fd_sc_hd__fill_1
X_6310_ _6248_/A _6309_/B _6310_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4571_ _5359_/B _5362_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_128_485 VGND VPWR sky130_fd_sc_hd__decap_4
X_7290_ _7290_/A _7290_/B _7350_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_6241_ _6232_/B _6175_/X _6218_/C _6202_/A _6242_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_130_105 VGND VPWR sky130_fd_sc_hd__decap_8
X_6172_ _6169_/X _6172_/B _6172_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5123_ _5123_/A _7641_/Q _6034_/A _5123_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_69_222 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_363 VGND VPWR sky130_fd_sc_hd__decap_3
X_5054_ east_clb_output[1] _5055_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4005_ _3981_/A conf_hcb[44] _4008_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_653 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_19 VGND VPWR sky130_fd_sc_hd__fill_1
X_5956_ _5956_/A _5915_/X _5956_/C _5956_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_52_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_4907_ _4891_/X _4904_/Y _4906_/X _4908_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5887_ _5856_/C _5873_/B _5805_/C _5836_/B _5888_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_138_205 VGND VPWR sky130_fd_sc_hd__decap_8
X_7626_ _7626_/D _7626_/Q _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4838_ _4838_/A _4837_/X _4838_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_463 VGND VPWR sky130_fd_sc_hd__fill_2
X_7557_ _4833_/Y _5981_/B _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_5_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_4769_ _4762_/X _5873_/A _4752_/X _4770_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_147_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_6508_ _6505_/X _6507_/X _6511_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_134_433 VGND VPWR sky130_fd_sc_hd__decap_8
X_7488_ clb_input_south[5] clb_input[21] VGND VPWR sky130_fd_sc_hd__buf_2
X_6439_ _6439_/A _6439_/B _6439_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_20_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_488 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_531 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_457 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_406 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_718 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_707 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_792 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_612 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_86 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_205 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_238 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_85 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_7 clb_input_west[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_455 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_252 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_639 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_650 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_704 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_203 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_428 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_217 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_623 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_6790_ _4117_/Y _7686_/Q _6790_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5810_ _5526_/X _5810_/B _5811_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_34_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_5741_ _7555_/Q north_double_in[0] _4835_/Y _5741_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_31_851 VGND VPWR sky130_fd_sc_hd__decap_3
X_7411_ _7410_/Y _7412_/B _7413_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_5672_ _4714_/A _7577_/Q _5672_/C _5706_/D _5673_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_4623_ _4645_/A conf_vcb[37] _4628_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_129_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_7342_ _7342_/A _7341_/X _7342_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_4554_ _4553_/Y _4554_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_764 VGND VPWR sky130_fd_sc_hd__decap_12
X_7273_ _7244_/X _7273_/B _7272_/X _7275_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_143_263 VGND VPWR sky130_fd_sc_hd__decap_8
X_6224_ _3836_/Y _6224_/B _6221_/Y _6351_/D _6224_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_116_477 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_306 VGND VPWR sky130_fd_sc_hd__decap_4
X_4485_ _4480_/Y _4484_/X _7619_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_106_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_149 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_840 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_339 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_469 VGND VPWR sky130_fd_sc_hd__decap_12
X_6155_ _6150_/X _6152_/Y _6153_/X _6154_/X _6155_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_100_834 VGND VPWR sky130_fd_sc_hd__decap_8
X_6086_ _4858_/Y _6082_/X _6086_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5106_ _5106_/A _5055_/A _5106_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_5037_ _5037_/A _5036_/X _7513_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_26_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_784 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_464 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_604 VGND VPWR sky130_fd_sc_hd__decap_6
X_6988_ _6988_/A _7029_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5939_ _5939_/A _7260_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_851 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_659 VGND VPWR sky130_fd_sc_hd__decap_12
X_7609_ _7609_/D _4544_/A _7529_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_154_528 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_720 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_10_0_clk clkbuf_3_5_0_clk/X clkbuf_5_21_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_134_230 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_733 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_777 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_523 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_567 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_773 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_442 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_161 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_194 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_219 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_274 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_594 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_233 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_447 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_436 VGND VPWR sky130_fd_sc_hd__fill_2
X_4270_ _4270_/A _7101_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_4_571 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_255 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_876 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_526 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_6911_ _6710_/A _6911_/B _6912_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6842_ _6839_/Y _6841_/X _6843_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_63_751 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_581 VGND VPWR sky130_fd_sc_hd__decap_8
X_3985_ _6553_/A _6558_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6773_ _6773_/A _6773_/B _6773_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_148_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_670 VGND VPWR sky130_fd_sc_hd__fill_1
X_5724_ _5715_/B _5659_/X _5691_/A _5681_/X _5724_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_149_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_506 VGND VPWR sky130_fd_sc_hd__decap_12
X_5655_ _5626_/X _5655_/B _5655_/C _5655_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_148_388 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_528 VGND VPWR sky130_fd_sc_hd__fill_1
X_4606_ _4612_/A conf_vcb[40] _4606_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7325_ _7321_/X _7322_/Y _7323_/X _7324_/X _7325_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5586_ _5582_/X _5583_/Y _5584_/X _5585_/Y _5588_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_144_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_263 VGND VPWR sky130_fd_sc_hd__fill_1
X_4537_ _7610_/Q _4537_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7256_ _7229_/X _7225_/D _7246_/X _7256_/D _7256_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4468_ _4463_/Y _4467_/X _4468_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_89_114 VGND VPWR sky130_fd_sc_hd__fill_1
X_6207_ _6218_/C _6232_/B _6196_/X _6198_/X _6237_/A VGND VPWR sky130_fd_sc_hd__and4_4
X_7187_ _7172_/X _7187_/B _7187_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4399_ _4405_/A conf_vcb[77] _4404_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6138_ _6138_/A _6138_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_58_512 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_68 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_686 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_39 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_6069_ _6067_/A _5007_/A west_single_in[0] _6067_/X _6068_/X east_single_out[0] VGND
+ VPWR sky130_fd_sc_hd__a32o_4
XFILLER_73_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_751 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_604 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_344 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_528 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_583 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_296 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_285 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_417 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_876 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_504 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_718 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_323 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_367 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_913 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_581 VGND VPWR sky130_fd_sc_hd__decap_8
X_3770_ _3699_/A _3770_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_478 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_652 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_528 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_696 VGND VPWR sky130_fd_sc_hd__decap_12
X_5440_ _5440_/A _5440_/B _5405_/A south_double_out[3] _5440_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_66_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_881 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_701 VGND VPWR sky130_fd_sc_hd__fill_1
X_5371_ _5375_/A _5339_/A _5368_/A south_double_out[1] _5371_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_7110_ _7110_/A _7120_/A _7110_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4322_ _7650_/Q _4322_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_5_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_4253_ _4253_/A _7127_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_87_607 VGND VPWR sky130_fd_sc_hd__decap_3
X_7041_ _4222_/A _7041_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_59_309 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_575 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_428 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_489 VGND VPWR sky130_fd_sc_hd__decap_12
X_4184_ _4178_/Y _4184_/B _4184_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_95_684 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_835 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_386 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_913 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_710 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6825_ _6784_/X _6800_/B _6817_/C _6824_/X _6821_/X _6825_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XPHY_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3968_ _3965_/Y _3968_/B _3968_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6756_ _6749_/X _6752_/Y _6753_/X _6755_/Y _6756_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XPHY_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_264 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_117 VGND VPWR sky130_fd_sc_hd__decap_12
X_5707_ _5707_/A _5679_/A _5689_/C _5862_/D _5707_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_148_152 VGND VPWR sky130_fd_sc_hd__fill_1
X_3899_ _6321_/A _3900_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_136_303 VGND VPWR sky130_fd_sc_hd__decap_12
X_6687_ _6652_/A _6658_/B _6676_/Y _6493_/X _6684_/X _6687_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_148_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_5638_ _5635_/A _4682_/Y _5628_/X _5571_/D _5638_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_128_68 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_806 VGND VPWR sky130_fd_sc_hd__decap_12
X_5569_ _5571_/A _4655_/Y _5571_/C _5568_/X _5534_/B _5569_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_151_339 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_200 VGND VPWR sky130_fd_sc_hd__decap_12
X_7308_ _7343_/A _4466_/X _7306_/A _7306_/B _7308_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_2_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_715 VGND VPWR sky130_fd_sc_hd__fill_1
X_7239_ _7238_/X _7239_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_104_288 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_707 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_846 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_367 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_913 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_740 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_581 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_336 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_673 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_618 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_737 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_61 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_640 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_504 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_356 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_838 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_529 VGND VPWR sky130_fd_sc_hd__decap_12
X_4940_ _4905_/X _4940_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4871_ _4867_/Y _4870_/X _4871_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_33_754 VGND VPWR sky130_fd_sc_hd__decap_4
X_6610_ _4012_/X _4020_/A _6610_/C _6481_/D _6610_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_3822_ _7736_/Q _6132_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_21_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_7590_ _4649_/Y _5533_/C _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6541_ _6531_/B _6541_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3753_ _3750_/Y _3753_/B _3753_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_459 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_325 VGND VPWR sky130_fd_sc_hd__decap_8
X_6472_ _6138_/A _6472_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3684_ _3706_/A _3702_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_482 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_678 VGND VPWR sky130_fd_sc_hd__decap_12
X_5423_ _5423_/A _5423_/B _5423_/C _5422_/X _5423_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_5354_ _5188_/X _5346_/Y _5354_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_142_873 VGND VPWR sky130_fd_sc_hd__decap_12
X_4305_ _7654_/Q _5111_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_99_275 VGND VPWR sky130_fd_sc_hd__fill_1
X_5285_ _7607_/Q _5184_/X _5190_/X _5281_/X _5285_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_101_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_7024_ _4186_/A _7024_/B _7023_/X _7026_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4236_ _4218_/X conf_hcb[5] _4236_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_4_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_4167_ _4161_/Y _4166_/X _4167_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_55_334 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_367 VGND VPWR sky130_fd_sc_hd__decap_3
X_4098_ _3681_/X _4372_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_24_721 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_754 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6808_ _4106_/A _7688_/Q _6801_/Y _6807_/Y _6808_/X VGND VPWR sky130_fd_sc_hd__or4_4
XPHY_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_415 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_623 VGND VPWR sky130_fd_sc_hd__decap_12
X_6739_ _4070_/X _4076_/A _6733_/Y _6739_/D _6739_/X VGND VPWR sky130_fd_sc_hd__or4_4
XPHY_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_177 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_317 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_520 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_71 _5131_/X _6036_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_60 psn_inst_psn_buff_60/A psn_inst_psn_buff_60/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_82 psn_inst_psn_buff_82/A psn_inst_psn_buff_80/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_79_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_647 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_93 _5564_/X _5698_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_372 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_575 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_695 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_684 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_183 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_301 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_860 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_409 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_634 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_306 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_199 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_501 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_534 VGND VPWR sky130_fd_sc_hd__fill_1
X_5070_ _5075_/C _5055_/A _5070_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4021_ _4011_/X _4020_/X _4002_/X _4021_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_29_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_857 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_676 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_367 VGND VPWR sky130_fd_sc_hd__fill_1
X_5972_ _5981_/A _5991_/B _5973_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_80_635 VGND VPWR sky130_fd_sc_hd__decap_6
X_7711_ _7711_/D _6448_/B _7713_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_80_646 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_337 VGND VPWR sky130_fd_sc_hd__decap_6
X_4923_ _4922_/X _4934_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_21_713 VGND VPWR sky130_fd_sc_hd__decap_12
X_4854_ _7552_/Q _4854_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7642_ _7642_/D _7642_/Q _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_3805_ _3863_/A _3805_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4785_ _4784_/Y _4785_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7573_ _7573_/D _4741_/A _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6524_ _3984_/A _6525_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_100 VGND VPWR sky130_fd_sc_hd__decap_8
X_3736_ _3736_/A _3736_/B _3736_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_109_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_6455_ _6486_/B _6455_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_106_328 VGND VPWR sky130_fd_sc_hd__decap_8
X_6386_ _6386_/A _6389_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_840 VGND VPWR sky130_fd_sc_hd__decap_12
X_5406_ _5439_/A _5406_/B _5407_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_121_309 VGND VPWR sky130_fd_sc_hd__decap_8
X_5337_ _5337_/A _5348_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_114_383 VGND VPWR sky130_fd_sc_hd__decap_3
X_5268_ _5280_/C _5280_/D _4532_/Y _5269_/B VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_130_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_4219_ _4218_/X conf_hcb[8] _4225_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7007_ _7016_/A _7012_/B _7016_/C _7012_/D _7007_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_68_492 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_312 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_323 VGND VPWR sky130_fd_sc_hd__decap_12
X_5199_ _7615_/Q _5165_/D _4520_/Y _5164_/X _5200_/A VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_56_665 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_698 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_378 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_849 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_657 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_337 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_882 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_189 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_713 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_702 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_112 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_510 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4570_ _4512_/X _4570_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_576 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_442 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_607 VGND VPWR sky130_fd_sc_hd__decap_3
X_6240_ _6240_/A _6205_/Y _6239_/X _6242_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_6171_ _6131_/C _6131_/D _6151_/Y _6170_/X _6169_/A _6172_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5122_ clb_output[3] _6034_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_97_576 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_204 VGND VPWR sky130_fd_sc_hd__decap_8
X_5053_ _5053_/A _5052_/X _7509_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_4004_ _3998_/Y _4004_/B _7706_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_65_462 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_92 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_27 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_31_0_clk clkbuf_5_31_0_clk/A _7628_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_5955_ _5955_/A _5955_/B _5956_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_5886_ _5884_/X _5885_/X _5888_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_52_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_893 VGND VPWR sky130_fd_sc_hd__decap_8
X_4906_ _4905_/X _4906_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7625_ _7625_/D _7625_/Q _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4837_ _4819_/X _4835_/Y _4836_/X _4837_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_21_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_565 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_576 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_604 VGND VPWR sky130_fd_sc_hd__decap_6
X_7556_ _4838_/Y _7556_/Q _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4768_ _5844_/A _5873_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7487_ clb_input_south[4] clb_input[20] VGND VPWR sky130_fd_sc_hd__buf_2
X_6507_ _3972_/X _6506_/X _6480_/C _6456_/X _6507_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3719_ _7757_/Q _5739_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4699_ _4681_/X _5673_/A _4698_/X _4699_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6438_ _6438_/A _6397_/B _6243_/C _6389_/X _6439_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_20_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_510 VGND VPWR sky130_fd_sc_hd__decap_8
X_6369_ _6359_/B _6175_/X _6330_/X _6324_/B _6369_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_130_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_447 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_643 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_782 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_676 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_337 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_635 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_465 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_318 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_15 VGND VPWR sky130_fd_sc_hd__decap_12
XANTENNA_8 clb_input_west[4] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_152_264 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_629 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_128 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_117 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_576 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_716 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_226 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_462 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_495 VGND VPWR sky130_fd_sc_hd__decap_8
X_5740_ _5742_/B east_double_in[3] _5740_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_96_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_649 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_504 VGND VPWR sky130_fd_sc_hd__decap_12
X_7410_ vertical_global[2] _7366_/X _7409_/X _7410_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_5671_ _5671_/A _5669_/X east_clb_input[5] VGND VPWR sky130_fd_sc_hd__nor2_4
X_4622_ _4510_/A _4645_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_116_401 VGND VPWR sky130_fd_sc_hd__decap_12
X_7341_ _4466_/X _6023_/X _7343_/A _7299_/B _7341_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4553_ _7607_/Q _4553_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7272_ _7272_/A _7271_/Y _7272_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4484_ _4481_/X _7392_/D _4471_/X _4484_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_144_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_253 VGND VPWR sky130_fd_sc_hd__fill_1
X_6223_ _3847_/Y _6193_/B _6228_/C _6228_/D _6223_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_116_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_437 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_6154_ _6148_/A _6163_/D _6151_/Y _6351_/D _6154_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6085_ _4863_/Y _7549_/Q south_double_in[3] _6083_/X _6084_/X north_double_out[1]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
X_5105_ _5104_/X south_double_out[2] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_57_226 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_248 VGND VPWR sky130_fd_sc_hd__decap_12
X_5036_ _5021_/X _5034_/Y _5035_/X _5036_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_25_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_635 VGND VPWR sky130_fd_sc_hd__decap_6
X_6987_ _6986_/X _6988_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5938_ _5899_/A _4803_/X _5935_/A _5935_/B _5938_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_13_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_649 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_863 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_548 VGND VPWR sky130_fd_sc_hd__fill_1
X_5869_ _5869_/A _5869_/B _5869_/C _7201_/D _5869_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_22_874 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_395 VGND VPWR sky130_fd_sc_hd__decap_8
X_7608_ _4551_/Y _7608_/Q _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_581 VGND VPWR sky130_fd_sc_hd__decap_12
X_7539_ _7539_/D _4915_/B _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_123_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_404 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_448 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_459 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_640 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_705 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_481 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_395 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_789 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_440 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_207 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_284 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_151 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_74 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_184 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_195 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_415 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_82 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_109 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_888 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_218 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_760 VGND VPWR sky130_fd_sc_hd__decap_3
X_6910_ _6909_/X _6911_/B _6910_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_82_549 VGND VPWR sky130_fd_sc_hd__decap_8
X_6841_ _6811_/C _4123_/X _6841_/C _6791_/A _6841_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_62_273 VGND VPWR sky130_fd_sc_hd__fill_2
X_3984_ _3984_/A _6553_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6772_ _6458_/X _6724_/X _6771_/X _6773_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_5723_ _7581_/Q _5689_/X _5722_/X _5725_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_149_879 VGND VPWR sky130_fd_sc_hd__decap_12
X_5654_ _5654_/A _5654_/B _5655_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_136_518 VGND VPWR sky130_fd_sc_hd__fill_1
X_4605_ _4602_/Y _4605_/B _7598_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7324_ _4449_/A _7317_/B _7306_/C _7260_/D _7324_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5585_ _5581_/A _5540_/X _5536_/X _5508_/X _5585_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_117_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_4536_ _4511_/A conf_vcb[53] _4540_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_117_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_297 VGND VPWR sky130_fd_sc_hd__decap_8
X_7255_ _4421_/Y _7629_/Q _7243_/X _4439_/A _7255_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4467_ _4454_/X _4466_/X _4444_/X _4467_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6206_ _7732_/Q _6218_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_7186_ _7181_/A _4411_/X _7185_/X _7188_/C VGND VPWR sky130_fd_sc_hd__a21o_4
X_4398_ _4425_/A _4405_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_470 VGND VPWR sky130_fd_sc_hd__fill_2
X_6137_ west_single_out[0] _6138_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_671 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_170 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_376 VGND VPWR sky130_fd_sc_hd__decap_8
X_6068_ _5003_/A _5203_/X _5007_/Y _6068_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_100_698 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_410 VGND VPWR sky130_fd_sc_hd__decap_4
X_5019_ _4922_/X _5033_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_616 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_638 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_649 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_367 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_304 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_531 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_429 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_888 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_354 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_432 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_284 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_660 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_664 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5370_ _5350_/A _5370_/B _5337_/A _5353_/B _5370_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_154_893 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_201 VGND VPWR sky130_fd_sc_hd__decap_8
X_4321_ _4321_/A conf_vcb[93] _4324_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_245 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_446 VGND VPWR sky130_fd_sc_hd__decap_12
X_4252_ _4281_/A _4252_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7040_ _7040_/A _7079_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_113_278 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_407 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_181 VGND VPWR sky130_fd_sc_hd__fill_2
X_4183_ _4162_/X _6965_/B _4182_/X _4184_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_103_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_847 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_891 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6824_ east_double_in[0] _6824_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_35_284 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_733 VGND VPWR sky130_fd_sc_hd__fill_2
X_3967_ _3953_/X _3966_/Y _3942_/X _3968_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6755_ _6759_/A _6758_/D _6730_/X _6754_/X _6755_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XPHY_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_5706_ _5715_/A _4720_/A _5700_/A _5706_/D _5706_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_50_287 VGND VPWR sky130_fd_sc_hd__decap_12
X_3898_ _3898_/A conf_hcb[62] _3903_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_136_315 VGND VPWR sky130_fd_sc_hd__decap_12
X_6686_ _6681_/X _6683_/Y _6684_/X _6685_/Y _6686_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_109_518 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_337 VGND VPWR sky130_fd_sc_hd__decap_6
X_5637_ _5637_/A _5635_/B _5637_/C _5637_/D _5637_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_3_818 VGND VPWR sky130_fd_sc_hd__decap_12
X_5568_ _5932_/A _5568_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_212 VGND VPWR sky130_fd_sc_hd__fill_2
X_7307_ _7309_/A _7343_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4519_ _4511_/A conf_vcb[56] _4524_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7238_ _7238_/A _7238_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_5499_ _5120_/Y _5499_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_598 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_7169_ _7201_/B _7169_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_59_855 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_844 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_151 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_825 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_302 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_473 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_858 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_527 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_752 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_490 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_197 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_685 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_40 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_73 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_237 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_259 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_368 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_730 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_711 VGND VPWR sky130_fd_sc_hd__decap_12
X_4870_ _4868_/X _4869_/Y _4859_/X _4870_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_60_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_733 VGND VPWR sky130_fd_sc_hd__fill_2
X_3821_ _3803_/A conf_hcb[75] _3827_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6540_ _6602_/A _6550_/A _6545_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_32_276 VGND VPWR sky130_fd_sc_hd__decap_12
X_3752_ _3733_/X _5127_/A _3747_/X _3753_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_9_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_145_123 VGND VPWR sky130_fd_sc_hd__decap_12
X_6471_ _6459_/X _6471_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_118_337 VGND VPWR sky130_fd_sc_hd__decap_6
X_3683_ _3949_/A _3706_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5422_ _5405_/A _5420_/X _5422_/C _5422_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_114_510 VGND VPWR sky130_fd_sc_hd__decap_8
X_5353_ _5375_/A _5353_/B _5368_/A north_double_out[3] _5353_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4304_ _4281_/A _4304_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5284_ _5188_/X _5284_/B _5289_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_141_384 VGND VPWR sky130_fd_sc_hd__decap_8
X_7023_ _7023_/A _7023_/B _7023_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4235_ _4235_/A _4235_/B _7667_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_101_259 VGND VPWR sky130_fd_sc_hd__decap_8
X_4166_ _4162_/X _6927_/A _4153_/X _4166_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_67_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_527 VGND VPWR sky130_fd_sc_hd__decap_12
X_4097_ _4097_/A _4097_/B _7690_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_130_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_305 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_711 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_541 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6807_ _6807_/A1 _6802_/Y _6806_/Y _6807_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XPHY_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4999_ _4999_/A _4999_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_51_585 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_596 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_602 VGND VPWR sky130_fd_sc_hd__decap_8
X_6738_ _6807_/A1 _6735_/Y _6737_/Y _6739_/D VGND VPWR sky130_fd_sc_hd__a21oi_4
XPHY_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_112 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_101 VGND VPWR sky130_fd_sc_hd__fill_2
X_6669_ _6606_/A1 _6666_/Y _6668_/Y _6670_/D VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_152_605 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_134 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_830 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_83 _7251_/B _7187_/B VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_72 _5130_/D _5100_/D VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_61 psn_inst_psn_buff_61/A psn_inst_psn_buff_61/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_50 psn_inst_psn_buff_54/X psn_inst_psn_buff_50/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_105_532 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_94 psn_inst_psn_buff_94/A psn_inst_psn_buff_94/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_449 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_611 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_836 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_677 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_711 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_747 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_585 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_101 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_546 VGND VPWR sky130_fd_sc_hd__decap_3
X_4020_ _4020_/A _4020_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_111_579 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_568 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_302 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_825 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_806 VGND VPWR sky130_fd_sc_hd__decap_8
X_5971_ _5979_/C _5971_/B _6033_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_92_474 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_699 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_154 VGND VPWR sky130_fd_sc_hd__decap_4
X_7710_ _7710_/D _7710_/Q _7713_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4922_ _3804_/A _4922_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7641_ _7641_/D _7641_/Q _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4853_ _4844_/A conf_sb[43] _4856_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_725 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_574 VGND VPWR sky130_fd_sc_hd__decap_8
X_3804_ _3804_/A _3863_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4784_ _5901_/A _4784_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7572_ _4749_/Y _7572_/Q _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6523_ _6522_/X _6550_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3735_ _3733_/X _5816_/A _3724_/X _3736_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6454_ _7713_/Q _6486_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_109_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5405_ _5405_/A _5405_/B _5405_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6385_ _6385_/A _6386_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_703 VGND VPWR sky130_fd_sc_hd__decap_4
X_5336_ _5359_/A _5337_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_125_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_224 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_213 VGND VPWR sky130_fd_sc_hd__decap_8
X_5267_ _5266_/X _5280_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_85_19 VGND VPWR sky130_fd_sc_hd__decap_3
X_4218_ _4100_/A _4218_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7006_ _4194_/A _7013_/B _7008_/C _6348_/A _7002_/X _7006_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_68_482 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_622 VGND VPWR sky130_fd_sc_hd__fill_1
X_5198_ _4503_/X _5229_/D _5195_/X _5197_/X _5166_/B _5198_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_4149_ _4139_/A conf_hcb[20] _4149_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_55_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_357 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_647 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_669 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_541 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_123 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_104 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_224 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_622 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_658 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_647 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_669 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_62 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_410 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_454 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6170_ west_double_in[2] _6170_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_41_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5121_ _5120_/Y south_double_out[0] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_5052_ _4911_/A _5051_/Y _5035_/X _5052_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4003_ _3982_/X _6536_/B _4002_/X _4004_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_37_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_5954_ _5906_/A _5906_/B _5914_/X _5881_/X _5917_/X _5955_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4905_ rst _4905_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5885_ _5873_/B _5659_/X _5856_/C _5836_/B _5885_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_21_500 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_4836_ _4809_/A _4836_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7624_ _7624_/D _7317_/B _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_544 VGND VPWR sky130_fd_sc_hd__decap_4
X_7555_ _7555_/D _7555_/Q _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_588 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_6506_ _6174_/Y _6506_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4767_ _4771_/A conf_vcb[11] _4767_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7486_ clb_input_south[3] clb_input[19] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_119_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_104 VGND VPWR sky130_fd_sc_hd__decap_8
X_3718_ _3718_/A conf_hcb[96] _3721_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4698_ _4725_/A _4698_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6437_ _6437_/A _6436_/X _6439_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_107_649 VGND VPWR sky130_fd_sc_hd__decap_8
X_6368_ _7725_/Q _6368_/B _6367_/X _6370_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_103_811 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_404 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_5319_ _4555_/X _5318_/X _5279_/X _5269_/B _5320_/B VGND VPWR sky130_fd_sc_hd__a211o_4
X_6299_ _6299_/A _6272_/Y _6298_/X _6301_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_103_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_216 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_828 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_699 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_300 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_511 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_872 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_566 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_559 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_9 clb_output[2] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_547 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_293 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_764 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_809 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_516 VGND VPWR sky130_fd_sc_hd__decap_3
X_5670_ _5813_/A _5670_/B _5671_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_42_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_4621_ _4621_/A _4621_/B _4621_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_117_903 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_251 VGND VPWR sky130_fd_sc_hd__decap_3
X_7340_ _7626_/Q _7340_/B _7339_/X _7342_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4552_ _4548_/A conf_vcb[50] _4557_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_143_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_210 VGND VPWR sky130_fd_sc_hd__decap_8
X_7271_ _7234_/A _7234_/B _7262_/Y _5877_/X _7268_/X _7271_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4483_ _7353_/D _7392_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_7_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_788 VGND VPWR sky130_fd_sc_hd__decap_12
X_6222_ _3836_/Y _6224_/B _6221_/Y _6046_/X _6218_/X _6222_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_124_490 VGND VPWR sky130_fd_sc_hd__decap_8
X_6153_ _6124_/A _3823_/X _6163_/C _6158_/D _6153_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_112_674 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_886 VGND VPWR sky130_fd_sc_hd__decap_12
X_6084_ _4863_/A east_double_in[3] _4869_/Y _6084_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_5104_ _7554_/Q _4850_/Y east_double_in[3] _5102_/X _5103_/X _5104_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_85_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_558 VGND VPWR sky130_fd_sc_hd__fill_2
X_5035_ _3793_/A _5035_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_72_219 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_271 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_411 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_241 VGND VPWR sky130_fd_sc_hd__decap_12
X_6986_ _6983_/X _6985_/X _6986_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_25_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_5937_ _4785_/X _5948_/D _5914_/X _5859_/X _5934_/X _5937_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_40_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_330 VGND VPWR sky130_fd_sc_hd__decap_12
X_5868_ _7329_/D _7201_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_7607_ _4557_/Y _7607_/Q _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4819_ _4819_/A _4819_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5799_ _5769_/X _5772_/Y _5798_/X _5799_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_119_262 VGND VPWR sky130_fd_sc_hd__decap_8
X_7538_ _7538_/D _7538_/Q _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_295 VGND VPWR sky130_fd_sc_hd__decap_8
X_7469_ _7469_/HI north_clb_input[21] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_150_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_901 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_731 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_794 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_260 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_669 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_786 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_639 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_152 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_185 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_875 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_886 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_196 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_210 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_574 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_769 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_30_0_clk clkbuf_5_31_0_clk/A _7629_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_79_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_330 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_94 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_411 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_260 VGND VPWR sky130_fd_sc_hd__decap_12
X_6840_ horizontal_global[1] _6841_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_47_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_904 VGND VPWR sky130_fd_sc_hd__decap_8
X_6771_ _6725_/Y _6770_/X _6771_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_22_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_477 VGND VPWR sky130_fd_sc_hd__decap_8
X_3983_ _3983_/A _3984_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5722_ _5720_/X _5722_/B _5722_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_148_313 VGND VPWR sky130_fd_sc_hd__decap_12
X_5653_ _5615_/A _5615_/B _5644_/Y _5511_/X _5650_/X _5654_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_31_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_560 VGND VPWR sky130_fd_sc_hd__decap_8
X_4604_ _4597_/X _5439_/A _4587_/X _4605_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5584_ _4660_/Y _4666_/X _5538_/X _5540_/X _5584_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_117_744 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_733 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_210 VGND VPWR sky130_fd_sc_hd__decap_4
X_7323_ _7291_/A _4465_/X _7293_/X _7289_/D _7323_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4535_ _4535_/A _4534_/X _4535_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_144_541 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_276 VGND VPWR sky130_fd_sc_hd__decap_8
X_7254_ _7229_/X _7225_/D _7246_/X _5932_/X _7225_/X _7254_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_4466_ _4465_/X _4466_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6205_ _3837_/X _3843_/X _6221_/A _6329_/D _6205_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_7185_ _4410_/A _5924_/X _5925_/X _7181_/X _7185_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_4397_ _4393_/Y _4397_/B _4397_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6136_ _6125_/B _6136_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_683 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_6067_ _6067_/A north_single_in[0] _6067_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_45_208 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_709 VGND VPWR sky130_fd_sc_hd__decap_8
X_5018_ _5015_/Y _5017_/X _7517_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_81_550 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_764 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_433 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_786 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_499 VGND VPWR sky130_fd_sc_hd__decap_12
X_6969_ _6968_/Y _6922_/X _6971_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_139_313 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_758 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_224 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_108 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_31 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_311 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_720 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_96 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_672 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_683 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_145_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_850 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_213 VGND VPWR sky130_fd_sc_hd__decap_8
X_4320_ _4320_/A _4320_/B _7651_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_235 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_458 VGND VPWR sky130_fd_sc_hd__decap_8
X_4251_ _4103_/A _4281_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_101_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_108 VGND VPWR sky130_fd_sc_hd__decap_4
X_4182_ _4091_/A _4182_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_845 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_6823_ _6818_/X _6820_/Y _6821_/X _6822_/Y _6823_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_35_296 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_611 VGND VPWR sky130_fd_sc_hd__decap_12
X_3966_ _6448_/A _3966_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6754_ _6423_/A _6754_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_806 VGND VPWR sky130_fd_sc_hd__decap_12
X_6685_ _6658_/A _6688_/D _6662_/X _6558_/D _6685_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_31_480 VGND VPWR sky130_fd_sc_hd__decap_8
X_5705_ _5716_/A _5715_/D _5689_/C _5784_/B1 _5702_/X _5705_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_50_299 VGND VPWR sky130_fd_sc_hd__decap_8
X_3897_ _3897_/A _3897_/B _3897_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5636_ _5635_/A _4682_/Y _5628_/X _5568_/X _5607_/B _5636_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_136_327 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5567_ _5571_/A _7589_/Q _5559_/X _5566_/X _5567_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_144_371 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_585 VGND VPWR sky130_fd_sc_hd__decap_8
X_7306_ _7306_/A _7306_/B _7306_/C _7242_/D _7340_/B VGND VPWR sky130_fd_sc_hd__and4_4
X_4518_ _4518_/A _4517_/X _7614_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5498_ _5491_/C _5498_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7237_ _7237_/A _7251_/A _7238_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4449_ _4449_/A _4449_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_566 VGND VPWR sky130_fd_sc_hd__decap_12
X_7168_ _7189_/B _7201_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_86_642 VGND VPWR sky130_fd_sc_hd__decap_12
X_6119_ _3812_/A _6163_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_7099_ _7662_/Q _7661_/Q _4253_/A _4260_/A _7100_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_74_804 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_485 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_463 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_388 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_881 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_425 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_767 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_778 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_789 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_0 _6112_/X west_single_out[2] VGND VPWR sky130_fd_sc_hd__buf_8
XFILLER_10_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_697 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_417 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_249 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_675 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_697 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_163 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_303 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_667 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_742 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_550 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_723 VGND VPWR sky130_fd_sc_hd__decap_8
X_3820_ _3820_/A _3819_/X _7737_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_907 VGND VPWR sky130_fd_sc_hd__decap_8
X_3751_ _5125_/A _5127_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_32_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_480 VGND VPWR sky130_fd_sc_hd__decap_8
X_6470_ _6470_/A _6470_/B _6470_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_71_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_3682_ _3681_/X _3949_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_135 VGND VPWR sky130_fd_sc_hd__fill_1
X_5421_ _5182_/X _5407_/B _5422_/C VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_126_371 VGND VPWR sky130_fd_sc_hd__decap_12
X_5352_ _5351_/X _5368_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4303_ _4321_/A conf_vcb[97] _4303_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_142_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_341 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_428 VGND VPWR sky130_fd_sc_hd__decap_6
X_7022_ _6991_/C _7017_/B _7008_/C _6833_/X _7021_/A _7023_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_59_119 VGND VPWR sky130_fd_sc_hd__decap_3
X_5283_ _4538_/X _4545_/X _5282_/X north_double_out[3] _5283_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4234_ _4220_/X _7069_/A _4211_/X _4235_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__decap_12
X_4165_ _6946_/A _6927_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_675 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_539 VGND VPWR sky130_fd_sc_hd__decap_4
X_4096_ _4069_/X _6780_/A _4091_/X _4097_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_130_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_509 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_520 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6806_ _6802_/Y _6805_/X _6781_/X _6806_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XPHY_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_553 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_428 VGND VPWR sky130_fd_sc_hd__decap_12
X_4998_ _4925_/X _4998_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_149_452 VGND VPWR sky130_fd_sc_hd__decap_12
X_3949_ _3949_/A _3950_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6737_ _6735_/Y _6736_/X _6714_/X _6737_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_137_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_124 VGND VPWR sky130_fd_sc_hd__decap_3
X_6668_ _6666_/Y _6667_/X _6647_/A _6668_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_6599_ _6582_/A _4029_/A _6599_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_136_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_861 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_40 psn_inst_psn_buff_51/X psn_inst_psn_buff_35/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5619_ _5618_/X _5619_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_152_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_360 VGND VPWR sky130_fd_sc_hd__decap_6
Xpsn_inst_psn_buff_51 psn_inst_psn_buff_51/A psn_inst_psn_buff_51/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_73 _5182_/X _5357_/B VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_62 psn_inst_psn_buff_62/A psn_inst_psn_buff_59/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_544 VGND VPWR sky130_fd_sc_hd__decap_4
Xpsn_inst_psn_buff_84 psn_inst_psn_buff_86/X psn_inst_psn_buff_82/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_95 psn_inst_psn_buff_97/X psn_inst_psn_buff_94/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_120_547 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_653 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_848 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_50 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_818 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_561 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_520 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_715 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_759 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_105 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_371 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_360 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_726 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_90 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_236 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_671 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_5970_ _7558_/Q _5981_/B _5970_/C _4821_/A _5971_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_33_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_881 VGND VPWR sky130_fd_sc_hd__decap_4
X_4921_ _4921_/A _4920_/X _7538_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7640_ _4371_/Y _7640_/Q _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4852_ _4849_/Y _4851_/X _7553_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_3803_ _3803_/A conf_hcb[78] _3810_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_33_597 VGND VPWR sky130_fd_sc_hd__fill_2
X_4783_ _4771_/A conf_vcb[8] _4783_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7571_ _7571_/D _5884_/A _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6522_ _6552_/A _6557_/B _6522_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_119_647 VGND VPWR sky130_fd_sc_hd__decap_8
X_3734_ _7754_/Q _5816_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6453_ _6452_/X _6453_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_119_669 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_809 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_477 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_39 VGND VPWR sky130_fd_sc_hd__decap_8
X_5404_ _5414_/C _5414_/D _5404_/C _5405_/B VGND VPWR sky130_fd_sc_hd__or3_4
X_6384_ _6384_/A _6413_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_812 VGND VPWR sky130_fd_sc_hd__decap_12
X_5335_ _5331_/C _5359_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_5266_ _4544_/A _5266_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_75_409 VGND VPWR sky130_fd_sc_hd__decap_12
X_7005_ _7017_/C _7008_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_4217_ _4214_/Y _4216_/X _7670_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_84_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5197_ _5932_/A _5197_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4148_ _4145_/Y _4148_/B _7682_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_56_645 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_4079_ _4069_/X _6726_/B _4060_/X _4080_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_43_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_818 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_520 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_553 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_715 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_102 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_236 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_76 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_634 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_851 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_372 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_873 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_447 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_436 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_691 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_680 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_501 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_119 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_523 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_214 VGND VPWR sky130_fd_sc_hd__decap_8
X_5120_ _7651_/Q _5118_/Y _5119_/X _5120_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_34_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_193 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_718 VGND VPWR sky130_fd_sc_hd__decap_12
X_5051_ _7509_/Q _5051_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4002_ _3973_/A _4002_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_66_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_399 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_902 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_881 VGND VPWR sky130_fd_sc_hd__decap_8
X_5953_ _5917_/X _5953_/B _5953_/C _5955_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_34_851 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_862 VGND VPWR sky130_fd_sc_hd__decap_8
X_5884_ _5884_/A _5884_/B _5884_/C _5884_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_4904_ _4904_/A _4904_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4835_ _7556_/Q _4835_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7623_ _4462_/Y _7309_/A _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_180 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_147_720 VGND VPWR sky130_fd_sc_hd__decap_12
X_7554_ _4848_/Y _7554_/Q _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4766_ _4761_/Y _4766_/B _4766_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6505_ _6505_/A _6505_/B _6505_/C _6505_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_119_455 VGND VPWR sky130_fd_sc_hd__decap_8
X_3717_ _3714_/Y _3717_/B _3717_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7485_ clb_input_south[2] clb_input[18] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_146_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_628 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4697_ _7581_/Q _5673_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_146_296 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_6436_ _6397_/B _6175_/X _6438_/A _6389_/X _6436_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6367_ _6367_/A _6367_/B _6367_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_130_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_672 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_823 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_523 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_416 VGND VPWR sky130_fd_sc_hd__decap_12
X_5318_ _6023_/A _5318_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_642 VGND VPWR sky130_fd_sc_hd__decap_12
X_6298_ _6296_/X _6297_/Y _6298_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_103_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_770 VGND VPWR sky130_fd_sc_hd__fill_1
X_5249_ _5174_/Y _5249_/B _5249_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_29_623 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_604 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_301 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_478 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_670 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_361 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_372 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_884 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_895 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_62 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_274 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_288 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_160 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_556 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_74 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_41 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_409 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_559 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_96 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_445 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_434 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_821 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_720 VGND VPWR sky130_fd_sc_hd__decap_12
X_4620_ _4597_/X _5503_/A _4614_/X _4621_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_30_353 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_4551_ _4551_/A _4550_/X _4551_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7270_ _7266_/X _7267_/Y _7268_/X _7269_/Y _7272_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_4482_ _4482_/A _7353_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_6221_ _6221_/A _6221_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6152_ _6148_/A _6163_/D _6151_/Y _6046_/X _6148_/X _6152_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_98_832 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_642 VGND VPWR sky130_fd_sc_hd__decap_4
X_5103_ _4850_/Y north_double_in[0] _4846_/Y _5103_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_112_686 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_6083_ _4863_/Y _6082_/X _6083_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5034_ _5034_/A _5034_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_93_592 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_283 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_423 VGND VPWR sky130_fd_sc_hd__decap_4
X_6985_ _7016_/A _6975_/B _6985_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_25_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_253 VGND VPWR sky130_fd_sc_hd__decap_4
X_5936_ _5931_/X _5933_/X _5934_/X _5935_/Y _5936_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_15_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_810 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5867_ _5856_/C _5867_/B _5831_/X _5867_/D _5867_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7606_ _7606_/D _5382_/A _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_342 VGND VPWR sky130_fd_sc_hd__decap_4
X_4818_ _4834_/A conf_vcb[2] _4823_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_375 VGND VPWR sky130_fd_sc_hd__fill_1
X_5798_ _5796_/X _5797_/Y _5798_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_154_509 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_403 VGND VPWR sky130_fd_sc_hd__decap_12
X_4749_ _4744_/Y _4748_/X _4749_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7537_ _4929_/Y _5149_/A _7529_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_135_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_285 VGND VPWR sky130_fd_sc_hd__fill_1
X_7468_ _7468_/HI north_clb_input[20] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_150_715 VGND VPWR sky130_fd_sc_hd__decap_12
X_6419_ _6419_/A _6419_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7399_ _7370_/A _7370_/B _7390_/Y _5076_/Y _7396_/X _7399_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_115_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_375 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_913 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_626 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_61 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_607 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_297 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_142 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_175 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_835 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_423 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_272 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_743 VGND VPWR sky130_fd_sc_hd__decap_8
X_3982_ _3953_/A _3982_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6770_ _6768_/Y _6770_/B _6770_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_51_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_670 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_618 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_629 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_117 VGND VPWR sky130_fd_sc_hd__decap_12
X_5721_ _5681_/A _5681_/B _5689_/C _5515_/X _5720_/A _5722_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_50_459 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_325 VGND VPWR sky130_fd_sc_hd__decap_8
X_5652_ _5648_/X _5649_/Y _5650_/X _5651_/Y _5654_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_129_550 VGND VPWR sky130_fd_sc_hd__decap_3
X_4603_ _5395_/A _5439_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5583_ _5538_/X _4656_/X _5576_/C _5505_/X _5580_/X _5583_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_7322_ _4449_/X _7297_/A _7306_/C _7322_/B1 _7319_/X _7322_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4534_ _4513_/X _4532_/Y _4533_/X _4534_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_116_255 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_7253_ _7229_/X _7629_/Q _7248_/X _7253_/D _7253_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4465_ _7291_/B _4465_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_89_106 VGND VPWR sky130_fd_sc_hd__decap_8
X_6204_ _6203_/X _6204_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7184_ _7184_/A _7184_/B _7184_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4396_ _4376_/X _4395_/X _4390_/X _4397_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6135_ west_single_out[3] _6122_/A _6144_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_133_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_494 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_323 VGND VPWR sky130_fd_sc_hd__decap_12
X_6066_ _6064_/A _5016_/A _5203_/X _6064_/X _6065_/X north_single_out[1] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
X_5017_ _4998_/X _5016_/Y _5012_/X _5017_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_39_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_798 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_275 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_489 VGND VPWR sky130_fd_sc_hd__fill_1
X_6968_ _6789_/X _6926_/A _6967_/X _6968_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_53_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_437 VGND VPWR sky130_fd_sc_hd__decap_12
X_6899_ _6899_/A _6899_/B _6900_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_5919_ _5919_/A _5919_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_564 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_575 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_277 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_247 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_236 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_651 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_577 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_94 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_835 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_588 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_902 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_412 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_82 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_551 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_306 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_862 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_426 VGND VPWR sky130_fd_sc_hd__fill_1
X_4250_ _4264_/A conf_hcb[3] _4257_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_258 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_4181_ _6915_/B _6965_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_121_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_676 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_378 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_592 VGND VPWR sky130_fd_sc_hd__fill_2
X_6822_ _4107_/X _6785_/X _6812_/C _6754_/X _6822_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_35_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_437 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_623 VGND VPWR sky130_fd_sc_hd__decap_12
X_3965_ _3959_/A conf_hcb[51] _3965_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6753_ _6769_/A _4087_/X _6758_/C _4077_/X _6753_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3896_ _3892_/X _3895_/X _3883_/X _3897_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6684_ _6700_/A _4058_/X _6688_/C _6684_/D _6684_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5704_ _5700_/X _5701_/X _5702_/X _5703_/Y _5704_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_137_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_5635_ _5635_/A _5635_/B _5635_/C _5634_/X _5635_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_128_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_531 VGND VPWR sky130_fd_sc_hd__decap_12
X_5566_ _5565_/X _5536_/X _5566_/C _5566_/X VGND VPWR sky130_fd_sc_hd__and3_4
X_7305_ _7312_/B _7306_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_4517_ _4513_/X _5244_/B _4499_/X _4517_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5497_ _5492_/X _5494_/Y _5495_/X _5496_/X _5497_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_144_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_7236_ _4433_/Y _7627_/Q _7251_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4448_ _7625_/Q _4449_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_132_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_781 VGND VPWR sky130_fd_sc_hd__fill_1
X_7167_ _7166_/X _7167_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4379_ _4379_/A _4379_/B _4379_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6118_ _6163_/C _6131_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_86_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_816 VGND VPWR sky130_fd_sc_hd__decap_8
X_7098_ _7098_/A _7096_/X north_clb_input[1] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_73_315 VGND VPWR sky130_fd_sc_hd__decap_8
X_6049_ _6047_/A _7533_/Q _5225_/B _6047_/X _6048_/X north_single_out[3] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_54_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_551 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_905 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_448 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_245 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_1 psn_inst_psn_buff_1/A _7061_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_10_610 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_320 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_301 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_687 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_175 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_529 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_123 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_754 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_776 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_768 VGND VPWR sky130_fd_sc_hd__decap_12
X_3750_ _3745_/A conf_hcb[89] _3750_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3681_ _3680_/Y _3681_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_64_3 VGND VPWR sky130_fd_sc_hd__decap_3
X_5420_ _5395_/A _5435_/B _5419_/X _5420_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5351_ _5351_/A _5333_/B _5351_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_153_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_383 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_534 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_245 VGND VPWR sky130_fd_sc_hd__decap_4
X_4302_ _4249_/A _4321_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5282_ _5281_/X _5282_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7021_ _7021_/A _7021_/B _7021_/C _7023_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4233_ _7054_/A _7069_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_4_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_610 VGND VPWR sky130_fd_sc_hd__decap_4
X_4164_ _6938_/A _6946_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4095_ _4095_/A _6780_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_67_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_145 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_595 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6805_ _7686_/Q _6803_/X _6804_/X _6798_/X _6805_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_23_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6736_ _4086_/A _6472_/X _6473_/X _6729_/X _6736_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XPHY_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4997_ _5015_/A conf_sb[12] _4997_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_23_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_3948_ _3945_/Y _3948_/B _3948_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_23_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_6667_ _6654_/B _6472_/X _6473_/X _6662_/A _6667_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_3879_ _3886_/A conf_hcb[65] _3879_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_137_659 VGND VPWR sky130_fd_sc_hd__decap_12
X_6598_ _6619_/A _6623_/B _6587_/X _6589_/X _6628_/A VGND VPWR sky130_fd_sc_hd__and4_4
Xpsn_inst_psn_buff_30 _6734_/X _6807_/A1 VGND VPWR sky130_fd_sc_hd__buf_8
X_5618_ _5618_/A _5633_/B _5618_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_152_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_873 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_52 psn_inst_psn_buff_56/X psn_inst_psn_buff_52/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_63 psn_inst_psn_buff_63/A psn_inst_psn_buff_60/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_41 _6732_/X _6733_/A VGND VPWR sky130_fd_sc_hd__buf_8
X_5549_ _5536_/X _5559_/B VGND VPWR sky130_fd_sc_hd__inv_8
Xpsn_inst_psn_buff_74 psn_inst_psn_buff_79/X _5186_/A2 VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_85 _7251_/B _5997_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_105 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_96 _5564_/X _5776_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_7219_ _7219_/A _7171_/X _7221_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_86_451 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_784 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_250 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_337 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_318 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_573 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_757 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_727 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_114 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_607 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_383 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_683 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_248 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_171 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_101 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_849 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_487 VGND VPWR sky130_fd_sc_hd__decap_8
X_4920_ _4891_/X _4919_/Y _4906_/X _4920_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4851_ _4845_/X _4850_/Y _4836_/X _4851_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_33_543 VGND VPWR sky130_fd_sc_hd__decap_6
X_3802_ _3832_/A _3803_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4782_ _4777_/Y _4782_/B _4782_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_60_384 VGND VPWR sky130_fd_sc_hd__fill_2
X_7570_ _7570_/D _7570_/Q _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_6521_ _3977_/Y _6520_/X _6521_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_3733_ _3733_/A _3733_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6452_ _3955_/A _6452_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_467 VGND VPWR sky130_fd_sc_hd__fill_1
X_5403_ _5440_/B _5414_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_117 VGND VPWR sky130_fd_sc_hd__decap_4
X_6383_ _6427_/A _6422_/B _6384_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5334_ _5334_/A _5341_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_150 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_375 VGND VPWR sky130_fd_sc_hd__decap_8
X_5265_ _5303_/C _5280_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_7004_ _7000_/X _7001_/X _7002_/X _7003_/Y _7004_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4216_ _4191_/X _7045_/C _4211_/X _4216_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5196_ south_single_in[0] _5932_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_96_760 VGND VPWR sky130_fd_sc_hd__decap_3
X_4147_ _4133_/X _6883_/A _4124_/X _4148_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_18_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_4078_ _4077_/X _6726_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_83_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_510 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7699_ _7699_/D _6644_/C _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_109_114 VGND VPWR sky130_fd_sc_hd__decap_8
X_6719_ _6758_/D _6720_/B VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_434 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_670 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_843 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_832 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_342 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_771 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_900 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_495 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_646 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_587 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_524 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_384 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_404 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_128_489 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_459 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_191 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_150 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_334 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_259 VGND VPWR sky130_fd_sc_hd__decap_8
X_5050_ _5050_/A conf_sb[0] _5053_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4001_ _6557_/B _6536_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_111_389 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_367 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_613 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_624 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_251 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_785 VGND VPWR sky130_fd_sc_hd__decap_8
X_5952_ _5952_/A _5951_/Y _5953_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_65_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_370 VGND VPWR sky130_fd_sc_hd__fill_1
X_4903_ _4889_/X conf_sb[32] _4908_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5883_ _5883_/A _5883_/B _5884_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_4834_ _4834_/A conf_sb[47] _4838_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7622_ _4468_/Y _4464_/A _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7553_ _7553_/D _4850_/A _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4765_ _4762_/X _5867_/D _4752_/X _4766_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6504_ _6504_/A _6504_/B _6505_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_3716_ _3710_/X _5747_/A _3699_/X _3717_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7484_ clb_input_south[1] clb_input[17] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_135_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_4696_ _4696_/A conf_vcb[24] _4696_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6435_ _6435_/A _6435_/B _6435_/C _6437_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_6366_ _6320_/X _6322_/X _6351_/C _6170_/X _6365_/A _6367_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_134_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_470 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_835 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_428 VGND VPWR sky130_fd_sc_hd__decap_6
X_5317_ vertical_global[0] _6023_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_142_492 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_632 VGND VPWR sky130_fd_sc_hd__decap_8
X_6297_ _6261_/A _6261_/B _6288_/Y _6082_/X _6294_/X _6297_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_103_879 VGND VPWR sky130_fd_sc_hd__decap_12
X_5248_ _5248_/A _5247_/X _5249_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_5179_ _5178_/X _5175_/B _5169_/A _5169_/B _5179_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_71_402 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_498 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_649 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_457 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_841 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_302 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_811 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_384 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_470 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_662 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_687 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_53 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_197 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_281 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_852 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_855 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_888 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_899 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4550_ _4543_/X _4549_/Y _4533_/X _4550_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_116_426 VGND VPWR sky130_fd_sc_hd__decap_12
X_4481_ _4376_/A _4481_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_143_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_6220_ _6216_/X _6217_/X _6218_/X _6219_/Y _6220_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_116_459 VGND VPWR sky130_fd_sc_hd__fill_1
X_6151_ _6122_/A _6151_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_112_621 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_5102_ _4850_/A _5102_/B _5102_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6082_ _6362_/A _6082_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_97_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_698 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_218 VGND VPWR sky130_fd_sc_hd__decap_8
X_5033_ _5033_/A conf_sb[4] _5037_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6984_ _7017_/C _6983_/X _6984_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_53_435 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_276 VGND VPWR sky130_fd_sc_hd__decap_6
X_5935_ _5935_/A _5935_/B _5919_/X _7192_/D _5935_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_15_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_5866_ _5831_/X _5867_/D _5864_/Y _5865_/X _5861_/X _5866_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_22_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_4817_ _4843_/A _4834_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7605_ _7605_/D _5331_/C _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_31_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5797_ _5759_/A _5759_/B _5788_/Y _5511_/X _5794_/X _5797_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_147_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_253 VGND VPWR sky130_fd_sc_hd__fill_2
X_4748_ _4735_/X _5805_/B _4725_/X _4748_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_5_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_7536_ _4933_/Y _7536_/Q _7514_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_415 VGND VPWR sky130_fd_sc_hd__decap_12
X_7467_ _7467_/HI north_clb_input[19] VGND VPWR sky130_fd_sc_hd__conb_1
X_4679_ _4733_/A _4696_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_135_757 VGND VPWR sky130_fd_sc_hd__decap_12
X_6418_ _6412_/X _6414_/Y _6415_/X _6417_/X _6418_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_150_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_470 VGND VPWR sky130_fd_sc_hd__fill_1
X_7398_ _7394_/X _7395_/Y _7396_/X _7397_/Y _7400_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_6349_ _3894_/Y _6321_/X _6351_/C _6348_/X _6343_/X _6349_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_103_632 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_310 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_737 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_387 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_638 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_413 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_649 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_446 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_660 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_619 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_468 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_143 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_844 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_693 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_630 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_176 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_855 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_198 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_619 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_542 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_520 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_803 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_302 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_376 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_847 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_91 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_741 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_593 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_733 VGND VPWR sky130_fd_sc_hd__decap_6
X_3981_ _3981_/A conf_hcb[48] _3981_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_62_265 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_254 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_682 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_5720_ _5720_/A _5694_/Y _5720_/C _5720_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_94_3 VGND VPWR sky130_fd_sc_hd__decap_4
X_5651_ _4676_/X _5613_/X _5621_/A _5508_/X _5651_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_117_702 VGND VPWR sky130_fd_sc_hd__decap_12
X_4602_ _4612_/A conf_vcb[41] _4602_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5582_ _5577_/X _5579_/Y _5580_/X _5581_/Y _5582_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_7321_ _7317_/X _7318_/X _7319_/X _7320_/Y _7321_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4533_ _4499_/A _4533_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_779 VGND VPWR sky130_fd_sc_hd__fill_2
X_7252_ _7252_/A _7228_/X _7252_/C _7253_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_7_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_6203_ _6203_/A _6203_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_116_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_407 VGND VPWR sky130_fd_sc_hd__decap_12
X_4464_ _4464_/A _7291_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_89_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_226 VGND VPWR sky130_fd_sc_hd__fill_1
X_4395_ _7196_/A _4395_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7183_ _4395_/X _4402_/X _7182_/X _7247_/D _7209_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_112_462 VGND VPWR sky130_fd_sc_hd__decap_8
X_6134_ _6129_/A _6129_/B _6133_/X _6210_/D _6134_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_133_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_836 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_335 VGND VPWR sky130_fd_sc_hd__fill_2
X_6065_ _7518_/Q east_single_in[1] _5016_/Y _6065_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_85_346 VGND VPWR sky130_fd_sc_hd__decap_12
X_5016_ _5016_/A _5016_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_39_763 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_284 VGND VPWR sky130_fd_sc_hd__decap_3
X_6967_ _6967_/A _6966_/X _6967_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_53_265 VGND VPWR sky130_fd_sc_hd__fill_1
X_5918_ _5916_/A _4802_/Y _5919_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_53_287 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_449 VGND VPWR sky130_fd_sc_hd__fill_1
X_6898_ _6859_/A _6858_/X _6881_/Y _6833_/X _6867_/X _6899_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_10_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_5849_ _5773_/A _5841_/Y _5849_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_306 VGND VPWR sky130_fd_sc_hd__decap_12
X_7519_ _5009_/Y _5007_/A _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_107_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_790 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_62 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_440 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_847 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_571 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_700 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_390 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_424 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_733 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_744 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_65 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_703 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_3_0_clk clkbuf_2_3_0_clk/A clkbuf_3_7_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_32_416 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_630 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_482 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_565 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_760 VGND VPWR sky130_fd_sc_hd__decap_3
X_4180_ _6930_/B _6915_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_95_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_292 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_195 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_700 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_755 VGND VPWR sky130_fd_sc_hd__decap_8
X_6821_ _6811_/C _6811_/D _6821_/C _6812_/B _6821_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_24_917 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_202 VGND VPWR sky130_fd_sc_hd__decap_12
X_3964_ _3959_/Y _3963_/X _7713_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6752_ _6758_/C _6726_/B _6750_/Y _6751_/X _6746_/X _6752_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_23_449 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_635 VGND VPWR sky130_fd_sc_hd__decap_12
X_3895_ _3894_/Y _3895_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6683_ _6688_/C _6658_/B _6682_/Y _6420_/X _6679_/X _6683_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5703_ _5700_/A _5706_/D _5709_/A _5571_/D _5703_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5634_ _5621_/A _5632_/X _5634_/C _5634_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_145_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_521 VGND VPWR sky130_fd_sc_hd__fill_1
X_7304_ _7299_/A _7312_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_5565_ _5565_/A _5564_/X _5565_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_117_565 VGND VPWR sky130_fd_sc_hd__decap_3
X_5496_ _5490_/A _7594_/Q _5496_/C _5223_/X _5496_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4516_ _5229_/D _5244_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4447_ _4436_/A conf_vcb[68] _4451_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7235_ _7228_/X _7237_/A _7235_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_104_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_7166_ _7189_/A _7166_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6117_ _3806_/X _6163_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_4378_ _4376_/X _4377_/Y _4365_/X _4379_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_86_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_666 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_335 VGND VPWR sky130_fd_sc_hd__fill_1
X_7097_ _7159_/A _7038_/X _7098_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6048_ _4939_/A east_single_in[3] _4944_/Y _6048_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_46_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_777 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_574 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_393 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_2 psn_inst_psn_buff_2/A _7123_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_139_134 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_189 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_510 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_543 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_532 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_554 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_332 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_793 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_898 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_292 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_806 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_198 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_187 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_758 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_493 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_780 VGND VPWR sky130_fd_sc_hd__decap_12
X_3680_ cset _3680_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_127_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5350_ _5350_/A _5350_/B _5348_/A _5348_/B _5379_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_126_395 VGND VPWR sky130_fd_sc_hd__fill_2
X_4301_ _4301_/A _4300_/X _7655_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5281_ _7608_/Q _4553_/Y _5281_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_114_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_7020_ _7018_/X _7020_/B _7021_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_4232_ _4218_/X conf_hcb[6] _4235_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_122_590 VGND VPWR sky130_fd_sc_hd__decap_12
X_4163_ _4163_/A _6938_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_110 VGND VPWR sky130_fd_sc_hd__decap_12
X_4094_ _4067_/X conf_hcb[29] _4097_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_56_839 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_647 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_135 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_703 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_883 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6804_ _6139_/Y _6804_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_90_190 VGND VPWR sky130_fd_sc_hd__decap_6
X_4996_ _4922_/X _5015_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3947_ _3921_/X _6456_/C _3942_/X _3948_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6735_ _6723_/B _6735_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_577 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_476 VGND VPWR sky130_fd_sc_hd__decap_12
X_6666_ _6655_/B _6666_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3878_ _3875_/Y _3878_/B _3878_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6597_ _6582_/A _6619_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_20 west_single_out[2] _6143_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_31 _6111_/X _6734_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5617_ _5608_/A _4691_/A _5633_/B VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_42 _6733_/A _6871_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5548_ _5547_/X _5598_/A VGND VPWR sky130_fd_sc_hd__inv_8
Xpsn_inst_psn_buff_53 psn_inst_psn_buff_53/A psn_inst_psn_buff_49/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_64 psn_inst_psn_buff_64/A psn_inst_psn_buff_61/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_384 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_75 psn_inst_psn_buff_75/A _7379_/B VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_86 psn_inst_psn_buff_86/A psn_inst_psn_buff_86/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_97 psn_inst_psn_buff_97/A psn_inst_psn_buff_97/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_7218_ _5908_/X _7174_/X _7217_/X _7219_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_5479_ _5478_/X _4636_/X _5466_/X _5468_/X _5479_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_132_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_611 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_600 VGND VPWR sky130_fd_sc_hd__decap_8
X_7149_ _4271_/X _6174_/Y _7126_/C _7110_/A _7150_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_58_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_519 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_496 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_12 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_669 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_500 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_511 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_544 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_566 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_780 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_88 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_485 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_192 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_387 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_538 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_695 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_839 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_308 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_522 VGND VPWR sky130_fd_sc_hd__fill_2
X_4850_ _4850_/A _4850_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_61_864 VGND VPWR sky130_fd_sc_hd__decap_12
X_3801_ _3949_/A _3832_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_6520_ _6520_/A _6520_/B _3983_/A _3990_/A _6520_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4781_ _4762_/X _5898_/A _4780_/X _4782_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_20_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_3732_ _3745_/A conf_hcb[93] _3736_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_446 VGND VPWR sky130_fd_sc_hd__decap_12
X_6451_ _6450_/X _6470_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_115 VGND VPWR sky130_fd_sc_hd__decap_8
X_6382_ _6389_/C _6382_/B _6446_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_5402_ _5423_/B _5440_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5333_ _5342_/A _5333_/B _5334_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_154_490 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_354 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_162 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_5264_ _5289_/A _5303_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_430 VGND VPWR sky130_fd_sc_hd__decap_12
X_7003_ _6979_/A _7012_/D _7010_/A _6053_/X _7003_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4215_ _7086_/A _7045_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_5195_ _5194_/X _5195_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_95_260 VGND VPWR sky130_fd_sc_hd__decap_3
X_4146_ _6866_/A _6883_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_29_806 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_817 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_828 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_593 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_4077_ _6712_/D _4077_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_55_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_349 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_105 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_533 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_588 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_352 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_739 VGND VPWR sky130_fd_sc_hd__decap_12
X_4979_ _4974_/A conf_sb[16] _4982_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_51_396 VGND VPWR sky130_fd_sc_hd__decap_8
X_7698_ _4051_/Y _7698_/Q _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6718_ _4076_/A _6758_/D VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_284 VGND VPWR sky130_fd_sc_hd__decap_3
X_6649_ _6688_/C _6652_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_137_468 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_630 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_379 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_422 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_411 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_88 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_850 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_533 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_831 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_396 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_107 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_346 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_470 VGND VPWR sky130_fd_sc_hd__decap_8
X_4000_ _6537_/B _6557_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_93_742 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_636 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_414 VGND VPWR sky130_fd_sc_hd__decap_8
X_5951_ _5906_/A _5906_/B _5942_/Y _5877_/X _5948_/X _5951_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_53_628 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_96 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_330 VGND VPWR sky130_fd_sc_hd__decap_4
X_4902_ _4899_/Y _4902_/B _4902_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_61_672 VGND VPWR sky130_fd_sc_hd__decap_6
X_5882_ _5832_/X _5834_/X _5862_/C _5881_/X _5845_/X _5883_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_33_352 VGND VPWR sky130_fd_sc_hd__decap_3
X_4833_ _4828_/Y _4833_/B _4833_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7621_ _7621_/D _7621_/Q _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_385 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_396 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_413 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_402 VGND VPWR sky130_fd_sc_hd__decap_8
X_7552_ _7552_/D _7552_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4764_ _5857_/B _5867_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_6503_ _6453_/X _6455_/X _6486_/C _6502_/X _6466_/X _6504_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_7483_ clb_input_south[0] clb_input[16] VGND VPWR sky130_fd_sc_hd__buf_2
X_3715_ _7758_/Q _5747_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6434_ _6432_/X _6433_/Y _6435_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_119_479 VGND VPWR sky130_fd_sc_hd__decap_8
X_4695_ _4690_/Y _4694_/X _4695_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_134_416 VGND VPWR sky130_fd_sc_hd__decap_8
X_6365_ _6365_/A _6365_/B _6365_/C _6367_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_115_663 VGND VPWR sky130_fd_sc_hd__decap_8
X_6296_ _6292_/X _6293_/Y _6294_/X _6295_/Y _6296_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_114_151 VGND VPWR sky130_fd_sc_hd__fill_2
X_5316_ _7611_/Q _5278_/X _5315_/X _5316_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_115_696 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_173 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_847 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5247_ _5178_/X _5175_/B _5247_/C _5170_/C _5247_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_130_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_357 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_208 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_794 VGND VPWR sky130_fd_sc_hd__decap_4
X_5178_ _5178_/A _5178_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_84_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_230 VGND VPWR sky130_fd_sc_hd__decap_12
X_4129_ _4104_/X _6859_/C _4124_/X _4130_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_71_414 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_303 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_864 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_558 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_254 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_514 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_699 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_742 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_414 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_285 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_9_0_clk clkbuf_5_9_0_clk/A _7571_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_15_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_864 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_298 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_438 VGND VPWR sky130_fd_sc_hd__decap_3
X_4480_ _4479_/X conf_vcb[62] _4480_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6150_ _6144_/X _6147_/X _6148_/X _6149_/Y _6150_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_112_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_5101_ _7761_/Q _5099_/Y _5100_/X _5102_/B VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_112_666 VGND VPWR sky130_fd_sc_hd__decap_8
X_6081_ _5102_/B _6362_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_85_506 VGND VPWR sky130_fd_sc_hd__decap_3
X_5032_ _5029_/Y _5032_/B _5032_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_111_198 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_241 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_433 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_756 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_296 VGND VPWR sky130_fd_sc_hd__decap_8
X_6983_ _6991_/C _7017_/B _4186_/Y _6983_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_5934_ _4784_/Y _5931_/B _5916_/X _4803_/X _5934_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_15_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_5865_ _5120_/Y _5865_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_61_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_683 VGND VPWR sky130_fd_sc_hd__decap_12
X_4816_ _4816_/A _4816_/B _4816_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7604_ _4574_/Y _5359_/B _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5796_ _5792_/X _5793_/Y _5794_/X _5795_/Y _5796_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_119_232 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_7535_ _4937_/Y _7535_/Q _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4747_ _4746_/X _5805_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_7466_ _7466_/HI north_clb_input[18] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_4678_ _4674_/Y _4677_/X _7585_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_135_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_6417_ _6417_/A _6424_/B _6413_/Y _6486_/D _6417_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7397_ _7397_/A _7396_/D _7363_/A _7333_/D _7397_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_150_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_257 VGND VPWR sky130_fd_sc_hd__decap_3
X_6348_ _6348_/A _6348_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_1_705 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_441 VGND VPWR sky130_fd_sc_hd__decap_12
X_6279_ _6257_/A _6290_/D _6272_/C _6146_/X _6254_/B _6279_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_103_655 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_132 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_176 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_591 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_455 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_100 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_823 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_672 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_166 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_867 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_199 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_563 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_227 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_550 VGND VPWR sky130_fd_sc_hd__fill_1
X_3980_ _3950_/A _3981_/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_806 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_0_clk clk clkbuf_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_5650_ _5608_/A _4693_/X _5611_/X _5613_/X _5650_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_87_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_4601_ _4596_/Y _4600_/X _4601_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_30_141 VGND VPWR sky130_fd_sc_hd__decap_12
X_5581_ _5581_/A _5540_/X _5571_/C _5791_/D _5581_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_117_714 VGND VPWR sky130_fd_sc_hd__decap_4
X_7320_ _7293_/X _7289_/D _7310_/X _7256_/D _7320_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_7_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_51 VGND VPWR sky130_fd_sc_hd__decap_8
X_4532_ _7611_/Q _4532_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_144_555 VGND VPWR sky130_fd_sc_hd__decap_8
X_7251_ _7251_/A _7251_/B _7252_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4463_ _4463_/A conf_vcb[65] _4463_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6202_ _6202_/A _6212_/A _6203_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_104_419 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_739 VGND VPWR sky130_fd_sc_hd__decap_12
X_7182_ _7181_/X _7182_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4394_ _7161_/C _7196_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_642 VGND VPWR sky130_fd_sc_hd__decap_8
X_6133_ _6132_/X _6133_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_85_303 VGND VPWR sky130_fd_sc_hd__fill_2
X_6064_ _6064_/A west_single_in[0] _6064_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_86_859 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_358 VGND VPWR sky130_fd_sc_hd__decap_8
X_5015_ _5015_/A conf_sb[8] _5015_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_391 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_296 VGND VPWR sky130_fd_sc_hd__decap_12
X_6966_ _6964_/Y _6965_/X _6966_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5917_ _5916_/X _4804_/X _5906_/A _5906_/B _5917_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6897_ _6867_/X _6870_/Y _6896_/X _6899_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_22_642 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5848_ _5869_/A _5867_/D _5869_/C _5848_/D _5848_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_148_861 VGND VPWR sky130_fd_sc_hd__decap_12
X_5779_ _5754_/X _5750_/D _5782_/C _5568_/X _5751_/B _5779_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_10_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_202 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_7518_ _5014_/Y _7518_/Q _7514_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_135_533 VGND VPWR sky130_fd_sc_hd__decap_12
X_7449_ _7449_/HI east_clb_input[25] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_107_257 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_196 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_712 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_531 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_77 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_447 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_88 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_831 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_428 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_290 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_772 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_634 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_623 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_645 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_166 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_881 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_712 VGND VPWR sky130_fd_sc_hd__decap_12
X_6820_ _6821_/C _6800_/B _6819_/Y _6751_/X _6816_/X _6820_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_36_778 VGND VPWR sky130_fd_sc_hd__decap_12
X_3963_ _3953_/X _3962_/X _3942_/X _3963_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6751_ _6420_/A _6751_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_480 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_647 VGND VPWR sky130_fd_sc_hd__decap_12
X_3894_ _6345_/A _3894_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6682_ _6662_/X _6682_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_31_461 VGND VPWR sky130_fd_sc_hd__fill_2
X_5702_ _5707_/A _5679_/A _5691_/A _4720_/A _5702_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5633_ _5564_/X _5633_/B _5634_/C VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_129_371 VGND VPWR sky130_fd_sc_hd__fill_1
X_5564_ _5928_/A _5564_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_842 VGND VPWR sky130_fd_sc_hd__decap_12
X_7303_ _7302_/X _7345_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_8_690 VGND VPWR sky130_fd_sc_hd__decap_12
X_4515_ _5165_/D _5229_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5495_ _4630_/Y _5495_/B _5491_/A _4625_/Y _5495_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_132_536 VGND VPWR sky130_fd_sc_hd__decap_12
X_7234_ _7234_/A _7234_/B _4416_/Y _7237_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4446_ _4446_/A _4446_/B _7626_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_750 VGND VPWR sky130_fd_sc_hd__decap_3
X_7165_ _7161_/C _7189_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4377_ _4377_/A _4377_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_450 VGND VPWR sky130_fd_sc_hd__decap_8
X_6116_ _6116_/A _6122_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_271 VGND VPWR sky130_fd_sc_hd__decap_4
X_7096_ _7096_/A _7038_/X _7096_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_37_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_689 VGND VPWR sky130_fd_sc_hd__decap_12
X_6047_ _6047_/A _6046_/X _6047_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_67_881 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_383 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_789 VGND VPWR sky130_fd_sc_hd__fill_1
X_6949_ _6917_/X _4171_/X _6948_/Y _6751_/X _6945_/X _6949_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_139_102 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_3 _6111_/X _6112_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_154_138 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_300 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_385 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_310 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_547 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_750 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_409 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_321 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_461 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_601 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_325 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_103 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_383 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_597 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_93 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_308 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_683 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_4300_ _4281_/X _5072_/A _4295_/X _4300_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5280_ _5279_/X _4555_/X _5280_/C _5280_/D _5280_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4231_ _4231_/A _4231_/B _4231_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_96_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_4162_ _4104_/A _4162_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_110_764 VGND VPWR sky130_fd_sc_hd__decap_12
X_4093_ _4093_/A _4092_/X _7691_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_95_475 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_464 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_453 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_604 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_870 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_520 VGND VPWR sky130_fd_sc_hd__fill_1
X_6803_ _6138_/A _6803_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_91_692 VGND VPWR sky130_fd_sc_hd__decap_8
X_4995_ _4992_/Y _4995_/B _4995_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3946_ _6505_/A _6456_/C VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6734_ _6734_/A _6734_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_6665_ _6602_/A _6658_/C _6670_/C VGND VPWR sky130_fd_sc_hd__nor2_4
X_3877_ _3863_/X _6294_/A _3854_/X _3878_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6596_ _4014_/X _4020_/X _6602_/B _6464_/D _6631_/B VGND VPWR sky130_fd_sc_hd__nor4_4
Xpsn_inst_psn_buff_21 west_single_out[2] _6277_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_10 _5065_/Y _5066_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5616_ _5621_/A _5618_/A _5667_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_118_886 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_43 _6401_/A _6732_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_32 _6734_/A psn_inst_psn_buff_1/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5547_ _5547_/A _5547_/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_54 psn_inst_psn_buff_59/X psn_inst_psn_buff_54/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_65 psn_inst_psn_buff_65/A psn_inst_psn_buff_62/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_396 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_87 _7251_/B _5929_/B VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_76 psn_inst_psn_buff_80/X _6045_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_98 _5148_/Y psn_inst_psn_buff_97/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_5478_ _7593_/Q _5478_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_4429_ _7225_/D _4429_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7217_ _7175_/Y _7216_/X _7217_/X VGND VPWR sky130_fd_sc_hd__or2_4
Xclkbuf_2_2_0_clk clkbuf_2_3_0_clk/A clkbuf_3_5_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_99_792 VGND VPWR sky130_fd_sc_hd__fill_1
X_7148_ _7148_/A _7148_/B _7148_/C _7148_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_59_645 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_634 VGND VPWR sky130_fd_sc_hd__fill_2
X_7079_ _7075_/A _7079_/B _7079_/C _6828_/D _7079_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_58_166 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_103 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_24 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_840 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_854 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_394 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_578 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_770 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_792 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_903 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_468 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_65 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_151 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_399 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_818 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_412 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_626 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_895 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_180 VGND VPWR sky130_fd_sc_hd__fill_1
X_3800_ _3797_/Y _3800_/B _3800_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4780_ _4809_/A _4780_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_61_876 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_589 VGND VPWR sky130_fd_sc_hd__decap_8
X_3731_ _3706_/A _3745_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_6450_ _3966_/Y _6480_/D _6450_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6381_ _6396_/A _6381_/B _6381_/C _6381_/D _6382_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_5401_ _5401_/A _5414_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_127_672 VGND VPWR sky130_fd_sc_hd__decap_12
X_5332_ _5340_/C _5332_/B _5393_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_142_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_707 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_729 VGND VPWR sky130_fd_sc_hd__decap_4
X_5263_ _7610_/Q _5289_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_174 VGND VPWR sky130_fd_sc_hd__decap_8
X_7002_ _4194_/A _6981_/A _7012_/A _7012_/B _7002_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4214_ _4189_/X conf_hcb[9] _4214_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5194_ _5178_/A _5194_/B _5194_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4145_ _4139_/A conf_hcb[21] _4145_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_442 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_795 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_283 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_401 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_626 VGND VPWR sky130_fd_sc_hd__decap_12
X_4076_ _4076_/A _6712_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_55_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_862 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_884 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_832 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_364 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4978_ _4978_/A _4977_/X _7526_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_149_241 VGND VPWR sky130_fd_sc_hd__decap_3
X_7697_ _4055_/Y _7697_/Q _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_3929_ _6381_/D _6422_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_6717_ _6758_/C _6720_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_296 VGND VPWR sky130_fd_sc_hd__decap_8
X_6648_ _6670_/A _6688_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_153_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_906 VGND VPWR sky130_fd_sc_hd__fill_1
X_6579_ _6579_/A _6521_/X _6581_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_133_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_130 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_399 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_489 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_895 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_309 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_62 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_692 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_681 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_545 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_843 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_66 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_567 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_425 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_650 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_314 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_559 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_401 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_765 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_754 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_404 VGND VPWR sky130_fd_sc_hd__fill_1
X_5950_ _5946_/X _5947_/Y _5948_/X _5949_/Y _5952_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_1_86 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_383 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_821 VGND VPWR sky130_fd_sc_hd__decap_3
X_4901_ _4891_/X _4900_/Y _4882_/X _4902_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7620_ _7620_/D _7353_/C _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5881_ south_double_in[2] _5881_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4832_ _4819_/X _5990_/B _4809_/X _4833_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_33_375 VGND VPWR sky130_fd_sc_hd__fill_1
X_7551_ _7551_/D _7551_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4763_ _5833_/A _5857_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_21_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_425 VGND VPWR sky130_fd_sc_hd__fill_2
X_6502_ west_double_in[2] _6502_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3714_ _3718_/A conf_hcb[97] _3714_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7482_ clb_cout clb_cout_west VGND VPWR sky130_fd_sc_hd__buf_2
X_4694_ _4681_/X _4693_/X _4671_/X _4694_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6433_ _6389_/A _6428_/B _6413_/Y _6170_/X _6397_/X _6433_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_146_288 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_406 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_119 VGND VPWR sky130_fd_sc_hd__decap_8
X_6364_ _6364_/A _6364_/B _6365_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_6295_ _6272_/A _6261_/B _6283_/A _6360_/D _6295_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5315_ _5312_/X _5314_/Y _5315_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5246_ vertical_global[1] _5247_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_261 VGND VPWR sky130_fd_sc_hd__decap_12
X_5177_ south_double_in[2] _5177_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_56_412 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_401 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_380 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_242 VGND VPWR sky130_fd_sc_hd__fill_2
X_4128_ _4128_/A _6859_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_4059_ _4058_/X _6700_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_84_776 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_692 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_304 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_662 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_537 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7749_ _7749_/D _7749_/Q _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_581 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_266 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_428 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_409 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_601 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_152 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_881 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_66 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_710 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_754 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_489 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_735 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_651 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_481 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_312 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_222 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_211 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_389 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_907 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_596 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5100_ _5100_/A _7760_/Q _7759_/Q _5100_/D _5100_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6080_ _4892_/A _4896_/Y north_double_in[1] _6078_/X _6079_/X east_double_out[3]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_98_879 VGND VPWR sky130_fd_sc_hd__decap_6
X_5031_ _5021_/X _5158_/A _5012_/X _5032_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_78_581 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_570 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_209 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_562 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_223 VGND VPWR sky130_fd_sc_hd__fill_1
X_6982_ _7013_/B _7017_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_81_768 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_267 VGND VPWR sky130_fd_sc_hd__decap_8
X_5933_ _5935_/A _5935_/B _5919_/X _5932_/X _5898_/B _5933_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_5864_ _5869_/C _5864_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_34_695 VGND VPWR sky130_fd_sc_hd__decap_6
X_4815_ _4792_/X _5993_/A _4809_/X _4816_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7603_ _7603_/D _5351_/A _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_367 VGND VPWR sky130_fd_sc_hd__decap_8
X_7534_ _4942_/Y _4939_/A _7529_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5795_ _4730_/X _5794_/D _5753_/X _5508_/X _5795_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4746_ _4745_/Y _4746_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_31_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_277 VGND VPWR sky130_fd_sc_hd__decap_8
X_7465_ _7465_/HI north_clb_input[17] VGND VPWR sky130_fd_sc_hd__conb_1
X_4677_ _4654_/X _4676_/X _4671_/X _4677_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6416_ _6416_/A _6486_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_7396_ _7364_/A _7407_/B _7396_/C _7396_/D _7396_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6347_ _6336_/A _6351_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_89_813 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_717 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_835 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_453 VGND VPWR sky130_fd_sc_hd__decap_4
X_6278_ _6257_/A _6259_/A _6278_/C _6277_/Y _6278_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_103_667 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_249 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_166 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_401 VGND VPWR sky130_fd_sc_hd__decap_12
X_5229_ _5178_/X _5234_/B _5229_/C _5229_/D _5229_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_29_467 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_584 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_267 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_134 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_312 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_101 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_806 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_189 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_542 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_575 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_721 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_554 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_643 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_654 VGND VPWR sky130_fd_sc_hd__decap_12
X_4600_ _4597_/X _5417_/B _4587_/X _4600_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XPHY_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5580_ _5552_/X _5574_/B _5538_/X _4656_/X _5580_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_129_586 VGND VPWR sky130_fd_sc_hd__decap_12
X_4531_ _4511_/A conf_vcb[54] _4535_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_8_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_545 VGND VPWR sky130_fd_sc_hd__fill_1
X_7250_ _7628_/Q _4439_/A _7249_/X _7252_/C VGND VPWR sky130_fd_sc_hd__a21o_4
X_4462_ _4459_/Y _4462_/B _4462_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_7_74 VGND VPWR sky130_fd_sc_hd__decap_12
X_6201_ _3847_/Y _6191_/B _6212_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_125_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_7181_ _7181_/A _7181_/B _7181_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4393_ _4384_/A conf_vcb[78] _4393_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_6132_ _7737_/Q _6132_/B _6132_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_86_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_518 VGND VPWR sky130_fd_sc_hd__fill_1
X_6063_ _6061_/A _7515_/Q east_single_in[0] _6061_/X _6062_/X west_single_out[0] VGND
+ VPWR sky130_fd_sc_hd__a32o_4
X_5014_ _5014_/A _5014_/B _5014_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_27_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_595 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_584 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_735 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_724 VGND VPWR sky130_fd_sc_hd__decap_8
X_6965_ _6965_/A _6965_/B _6841_/C _6922_/B _6965_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_81_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_459 VGND VPWR sky130_fd_sc_hd__decap_12
X_5916_ _5916_/A _5916_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6896_ _6896_/A _6896_/B _6896_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_42_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_5847_ _5847_/A _5869_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_5778_ _5754_/X _4736_/A _5778_/C _5778_/D _5778_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_10_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_715 VGND VPWR sky130_fd_sc_hd__decap_12
X_4729_ _7575_/Q _4729_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7517_ _7517_/D _5016_/A _7514_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_135_545 VGND VPWR sky130_fd_sc_hd__decap_4
X_7448_ _7448_/HI east_clb_input[24] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_107_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_225 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_214 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_5_8_0_clk clkbuf_5_9_0_clk/A _7592_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_104_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_632 VGND VPWR sky130_fd_sc_hd__decap_6
X_7379_ _7364_/X _7379_/B _7380_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_107_86 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_507 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_518 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_614 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_698 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_383 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_93 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_386 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_729 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_280 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_153 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_657 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_326 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_189 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_724 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_584 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_6750_ _6730_/X _6750_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_90_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_3962_ _6481_/B _3962_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5701_ _5700_/A _5706_/D _5709_/A _5568_/X _5673_/B _5701_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_3893_ _3893_/A _6345_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6681_ _6675_/X _6678_/Y _6679_/X _6680_/X _6681_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_149_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_136 VGND VPWR sky130_fd_sc_hd__decap_12
X_5632_ _5627_/A _5637_/D _5631_/X _5632_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_117_501 VGND VPWR sky130_fd_sc_hd__decap_12
X_5563_ _7588_/Q _5574_/B _5562_/X _5566_/C VGND VPWR sky130_fd_sc_hd__a21o_4
X_7302_ _7301_/X _7302_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4514_ _7614_/Q _5165_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_5494_ _5503_/A _5503_/B _5496_/C _5784_/B1 _5490_/X _5494_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_7233_ _7232_/X _7234_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_228 VGND VPWR sky130_fd_sc_hd__decap_12
X_4445_ _4427_/X _7290_/A _4444_/X _4446_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_132_548 VGND VPWR sky130_fd_sc_hd__decap_4
X_7164_ _7164_/A _7164_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4376_ _4376_/A _4376_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6115_ _6124_/A _3823_/X _6116_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_113_773 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_401 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_434 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_123 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_7095_ _7094_/Y _7093_/X _7096_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_6046_ _6348_/A _6046_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_100_445 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_808 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_893 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_543 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_587 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_407 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_6948_ _6941_/C _6948_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_53_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_114 VGND VPWR sky130_fd_sc_hd__decap_8
X_6879_ _6855_/A _6879_/B _6889_/C _6674_/D _6879_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_22_440 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_4 psn_inst_psn_buff_4/A _5295_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_154_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_309 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_333 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_473 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_337 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_668 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_649 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_381 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_392 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_874 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_395 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_440 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_695 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_204 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_672 VGND VPWR sky130_fd_sc_hd__decap_12
X_4230_ _4220_/X _7056_/B _4211_/X _4231_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_141_367 VGND VPWR sky130_fd_sc_hd__decap_8
X_4161_ _4161_/A conf_hcb[18] _4161_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_67_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_776 VGND VPWR sky130_fd_sc_hd__decap_4
X_4092_ _4069_/X _6769_/B _4091_/X _4092_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_68_679 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_145 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_115 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_318 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_863 VGND VPWR sky130_fd_sc_hd__decap_12
X_6802_ _6790_/X _6802_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_36_565 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_384 VGND VPWR sky130_fd_sc_hd__fill_2
X_4994_ _4975_/X _5161_/A _4989_/X _4995_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_3945_ _3919_/X conf_hcb[54] _3945_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6733_ _6733_/A _6721_/A _6733_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6664_ _6658_/A _6658_/B _6662_/X _6664_/D _6664_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_32_793 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_309 VGND VPWR sky130_fd_sc_hd__decap_8
X_3876_ _6270_/A _6294_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5615_ _5615_/A _5615_/B _5607_/A _5618_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_31_281 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_22 west_single_out[2] _6340_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
X_6595_ _6594_/X _6636_/A VGND VPWR sky130_fd_sc_hd__inv_8
Xpsn_inst_psn_buff_11 _6100_/X west_single_out[3] VGND VPWR sky130_fd_sc_hd__buf_8
Xpsn_inst_psn_buff_55 psn_inst_psn_buff_60/X psn_inst_psn_buff_51/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_44 psn_inst_psn_buff_44/A psn_inst_psn_buff_44/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_609 VGND VPWR sky130_fd_sc_hd__fill_1
X_5546_ _5546_/A _5565_/A _5547_/A VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_33 psn_inst_psn_buff_38/X psn_inst_psn_buff_27/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_301 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_898 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_66 psn_inst_psn_buff_66/A psn_inst_psn_buff_63/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_77 _6045_/A _6677_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_88 psn_inst_psn_buff_90/X psn_inst_psn_buff_86/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5477_ _5466_/X _5468_/X _5496_/C _5277_/X _5518_/B VGND VPWR sky130_fd_sc_hd__and4_4
Xpsn_inst_psn_buff_99 _5493_/X _5784_/B1 VGND VPWR sky130_fd_sc_hd__buf_8
XFILLER_133_879 VGND VPWR sky130_fd_sc_hd__decap_12
X_4428_ _7629_/Q _7225_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_105_548 VGND VPWR sky130_fd_sc_hd__fill_1
X_7216_ _7214_/Y _7216_/B _7216_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_132_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_760 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_900 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_7147_ _7145_/X _7146_/Y _7148_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_4359_ _7642_/Q _5123_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_100_242 VGND VPWR sky130_fd_sc_hd__decap_8
X_7078_ _7069_/A _7078_/B _7041_/X _7075_/B _7078_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_104_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_6029_ _5908_/X _5983_/X _6028_/X _6030_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_86_476 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_159 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_392 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_885 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_367 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_281 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_649 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_608 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_126 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_554 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_682 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_310 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_888 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_3730_ _3730_/A _3730_/B _7755_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_60_398 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_376 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_147_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_426 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_459 VGND VPWR sky130_fd_sc_hd__decap_8
X_6380_ _6380_/A _6380_/B clb_input[4] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_62_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5400_ _5423_/A _5401_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_127_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_5331_ _5351_/A _5342_/B _5331_/C _5362_/B _5332_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_142_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_131 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_507 VGND VPWR sky130_fd_sc_hd__decap_12
X_7001_ _6979_/A _7012_/D _7010_/A _6809_/X _6976_/B _7001_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_5262_ _5261_/X _5262_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_529 VGND VPWR sky130_fd_sc_hd__decap_12
X_4213_ _4207_/Y _4213_/B _7671_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5193_ _5192_/X _5186_/X _4503_/X _7614_/Q _5193_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4144_ _4144_/A _4143_/X _4144_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_454 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_638 VGND VPWR sky130_fd_sc_hd__decap_3
X_4075_ _4067_/X conf_hcb[32] _4075_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_83_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_159 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_373 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_384 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6716_ _4070_/X _6758_/C VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4977_ _4975_/X _4976_/Y _4966_/X _4977_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_51_376 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_404 VGND VPWR sky130_fd_sc_hd__fill_2
X_3928_ _6387_/A _6381_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_7696_ _4062_/Y _6654_/B _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_137_415 VGND VPWR sky130_fd_sc_hd__decap_12
X_3859_ _3834_/X _3858_/Y _3854_/X _3859_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6647_ _6647_/A _6658_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_109_106 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_6578_ _6577_/Y _6576_/X _6579_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_109_139 VGND VPWR sky130_fd_sc_hd__decap_8
X_5529_ _5529_/A _5529_/B _5532_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_133_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_334 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_323 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_879 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_378 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_337 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_562 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_874 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_384 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_855 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_685 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_459 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_730 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_435 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_276 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_362 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_5880_ _5845_/X _5848_/Y _5880_/C _5883_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_52_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_395 VGND VPWR sky130_fd_sc_hd__fill_2
X_4900_ _7542_/Q _4900_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4831_ _4831_/A _5990_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_34_877 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_1_0_clk clkbuf_1_0_0_clk/X clkbuf_3_3_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_7550_ _7550_/D _4863_/A _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4762_ _4735_/A _4762_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_201 VGND VPWR sky130_fd_sc_hd__decap_12
X_6501_ _6466_/X _6501_/B _6501_/C _6504_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_7481_ clb_cout clb_cout_south VGND VPWR sky130_fd_sc_hd__buf_2
X_3713_ _3713_/A _3712_/X _3713_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4693_ _5637_/D _4693_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_757 VGND VPWR sky130_fd_sc_hd__decap_12
X_6432_ _6397_/X _6400_/Y _6432_/C _6432_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_6363_ _6320_/X _6322_/X _6353_/Y _6362_/X _6359_/X _6364_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_142_462 VGND VPWR sky130_fd_sc_hd__decap_8
X_6294_ _6294_/A _6269_/B _6258_/A _6260_/A _6294_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_103_827 VGND VPWR sky130_fd_sc_hd__fill_1
X_5314_ _5280_/C _5280_/D _5299_/C _5313_/X _5280_/X _5314_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_69_730 VGND VPWR sky130_fd_sc_hd__fill_2
X_5245_ _5244_/X _5242_/X _5248_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_29_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_711 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_273 VGND VPWR sky130_fd_sc_hd__fill_2
X_5176_ south_double_in[3] _5176_/B _5242_/C VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_110_392 VGND VPWR sky130_fd_sc_hd__decap_4
X_4127_ _4110_/A conf_hcb[24] _4127_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4058_ _4058_/A _4058_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_56_468 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_833 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_305 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_99 VGND VPWR sky130_fd_sc_hd__fill_2
X_7748_ _7748_/D _3761_/A _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_61_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_847 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_7679_ _4167_/Y _4163_/A _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_153_705 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_462 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_451 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_440 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_687 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_189 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_178 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_714 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_777 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_265 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_254 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_800 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_479 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_747 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_671 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_471 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_376 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_493 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_379 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_245 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_564 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_5030_ _7514_/Q _5158_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_402 VGND VPWR sky130_fd_sc_hd__fill_1
X_6981_ _6981_/A _7013_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_619 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_468 VGND VPWR sky130_fd_sc_hd__decap_12
X_5932_ _5932_/A _5932_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_80_257 VGND VPWR sky130_fd_sc_hd__fill_1
X_5863_ _5858_/X _5860_/Y _5861_/X _5862_/X _5863_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_22_825 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_663 VGND VPWR sky130_fd_sc_hd__decap_3
X_4814_ _6001_/A _5993_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7602_ _7602_/D _5342_/B _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_5794_ _4741_/Y _5805_/B _5755_/X _5794_/D _5794_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_147_510 VGND VPWR sky130_fd_sc_hd__decap_12
X_4745_ _7572_/Q _4745_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7533_ _7533_/D _7533_/Q _7514_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_7464_ _7464_/HI north_clb_input[16] VGND VPWR sky130_fd_sc_hd__conb_1
X_4676_ _5637_/A _4676_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6415_ _6427_/A _6422_/B _6386_/A _6422_/D _6415_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7395_ _7396_/C _7392_/D _7370_/C _5104_/X _7392_/X _7395_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6346_ _6341_/X _6342_/X _6343_/X _6345_/Y _6346_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_115_451 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_462 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_847 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_292 VGND VPWR sky130_fd_sc_hd__decap_8
X_6277_ _6277_/A1 _6274_/Y _6276_/Y _6277_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_57_711 VGND VPWR sky130_fd_sc_hd__decap_8
X_5228_ _5169_/A _5244_/B _5227_/Y south_double_out[0] _5215_/X _5228_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_97_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_733 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_413 VGND VPWR sky130_fd_sc_hd__decap_12
X_5159_ _7514_/Q west_single_in[1] _5034_/Y _5159_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_72_703 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_243 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_479 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_596 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_76 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_124 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_803 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_102 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_179 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_259 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_302 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_530 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_566 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_599 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_510 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_91 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_666 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4530_ _4530_/A _4530_/B _7612_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_8_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_215 VGND VPWR sky130_fd_sc_hd__decap_6
X_4461_ _4454_/X _7291_/A _4444_/X _4462_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_7_86 VGND VPWR sky130_fd_sc_hd__decap_12
X_6200_ _6221_/A _6202_/A _6247_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_7180_ _7191_/C _4412_/X _7167_/X _7169_/X _7209_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_131_218 VGND VPWR sky130_fd_sc_hd__decap_8
X_6131_ _6179_/A _6179_/B _6131_/C _6131_/D _6169_/A VGND VPWR sky130_fd_sc_hd__and4_4
X_4392_ _4388_/Y _4392_/B _7636_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_98_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_443 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_828 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_711 VGND VPWR sky130_fd_sc_hd__decap_8
X_6062_ _7516_/Q north_single_in[1] _5026_/Y _6062_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_100_649 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_5013_ _4998_/X _6064_/A _5012_/X _5014_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_94_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_703 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_747 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_213 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_276 VGND VPWR sky130_fd_sc_hd__decap_8
X_6964_ _6962_/X _6963_/X _6964_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_81_566 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_257 VGND VPWR sky130_fd_sc_hd__decap_8
X_6895_ _6859_/A _6858_/X _6886_/Y _6691_/X _6892_/X _6896_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5915_ _5906_/A _5906_/B _5914_/X _5915_/D _5915_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_41_408 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_110 VGND VPWR sky130_fd_sc_hd__decap_12
X_5846_ _5844_/A _4773_/A _5847_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_22_655 VGND VPWR sky130_fd_sc_hd__decap_8
X_5777_ _5777_/A _5753_/X _5775_/X _5778_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_108_727 VGND VPWR sky130_fd_sc_hd__decap_8
X_4728_ _4723_/A conf_vcb[18] _4728_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7516_ _7516_/D _7516_/Q _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7447_ _7447_/HI east_clb_input[23] VGND VPWR sky130_fd_sc_hd__conb_1
X_4659_ _4651_/X conf_vcb[31] _4662_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_123_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_7378_ _7353_/A _4492_/X _7377_/X _7380_/C VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_1_515 VGND VPWR sky130_fd_sc_hd__decap_12
X_6329_ _3895_/X _3901_/X _6336_/A _6329_/D _6368_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_88_121 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_806 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_24 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_46 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_739 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_622 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_626 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_463 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_474 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_800 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_395 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_828 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_187 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_669 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_809 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_820 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_533 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_747 VGND VPWR sky130_fd_sc_hd__fill_1
X_3961_ _3960_/Y _6481_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_63_588 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_385 VGND VPWR sky130_fd_sc_hd__decap_12
X_5700_ _5700_/A _5679_/A _5700_/C _5700_/D _5700_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_50_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_3892_ _3863_/A _3892_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6680_ _6672_/A _6688_/D _6676_/Y _6486_/D _6680_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_92_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_148 VGND VPWR sky130_fd_sc_hd__decap_4
X_5631_ _4691_/A _5560_/X _5561_/X _5628_/A _5631_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_5562_ _4664_/A _5560_/X _5561_/X _5555_/A _5562_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_144_321 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_513 VGND VPWR sky130_fd_sc_hd__decap_8
X_7301_ _7299_/B _7301_/B _7301_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4513_ _4512_/X _4513_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_7232_ _7629_/Q _7232_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5493_ _5859_/A _5493_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_505 VGND VPWR sky130_fd_sc_hd__decap_12
X_4444_ _4417_/A _4444_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_125_590 VGND VPWR sky130_fd_sc_hd__decap_3
X_7163_ _7163_/A _7181_/B _7164_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4375_ _4103_/A _4376_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6114_ _6114_/A _6114_/B _6187_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_113_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_305 VGND VPWR sky130_fd_sc_hd__decap_12
X_7094_ _7156_/A _7094_/B _7094_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_413 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_102 VGND VPWR sky130_fd_sc_hd__decap_3
X_6045_ _6045_/A _6348_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_58_349 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_327 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_419 VGND VPWR sky130_fd_sc_hd__decap_6
X_6947_ _6942_/X _6944_/Y _6945_/X _6946_/X _6947_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_42_739 VGND VPWR sky130_fd_sc_hd__decap_4
X_6878_ _6884_/A _6857_/A _6867_/A _6883_/B _6878_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_22_452 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_750 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_148 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_126 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_5 psn_inst_psn_buff_5/A _5214_/A2 VGND VPWR sky130_fd_sc_hd__buf_1
X_5829_ _5829_/A _5875_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_794 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_452 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_345 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_571 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_56 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_179 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_820 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_371 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_149 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_691 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_363 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_463 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_794 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_293 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_489 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_652 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_313 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_216 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_549 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_4160_ _4100_/A _4161_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_110_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_4091_ _4091_/A _4091_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_67_157 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_135 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_850 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_639 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_127 VGND VPWR sky130_fd_sc_hd__decap_8
X_6801_ _6733_/A _6782_/X _6801_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_91_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_875 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_577 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_5_7_0_clk clkbuf_5_7_0_clk/A _7750_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_17_791 VGND VPWR sky130_fd_sc_hd__fill_2
X_4993_ _4993_/A _5161_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_3944_ _3937_/Y _3944_/B _7716_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6732_ _6732_/A _6732_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3875_ _3886_/A conf_hcb[66] _3875_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6663_ _6663_/A _6664_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_772 VGND VPWR sky130_fd_sc_hd__fill_1
X_5614_ _5613_/X _5615_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_31_293 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_12 west_single_out[3] _6336_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6594_ _6594_/A _6594_/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_23 west_single_out[2] _6215_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_129_192 VGND VPWR sky130_fd_sc_hd__fill_1
Xpsn_inst_psn_buff_45 _6401_/X _6602_/A VGND VPWR sky130_fd_sc_hd__buf_8
Xpsn_inst_psn_buff_56 _6111_/X psn_inst_psn_buff_56/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5545_ _4660_/Y _4664_/A _5565_/A VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_34 psn_inst_psn_buff_34/A psn_inst_psn_buff_28/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_376 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_67 psn_inst_psn_buff_67/A psn_inst_psn_buff_65/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_78 _5182_/X _5486_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5476_ _5483_/B _5496_/C VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_89 _5564_/X _5852_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_195 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_324 VGND VPWR sky130_fd_sc_hd__decap_12
X_7215_ _7191_/C _4412_/X _7215_/C _7173_/A _7216_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_4427_ _4376_/A _4427_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7146_ _7104_/X _7106_/X _7132_/C west_double_in[2] _7115_/X _7146_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_87_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_794 VGND VPWR sky130_fd_sc_hd__fill_2
X_4358_ _4368_/A conf_vcb[85] _4361_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_48_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_221 VGND VPWR sky130_fd_sc_hd__decap_8
X_4289_ _4285_/A conf_vcb[100] _4292_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7077_ _7053_/C _7056_/B _7067_/Y _6824_/X _7074_/X _7077_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_58_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_44 VGND VPWR sky130_fd_sc_hd__decap_6
X_6028_ _5984_/Y _6028_/B _6028_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_67_680 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_298 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_875 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_227 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_794 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_346 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_145_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_357 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_466 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_477 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_672 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_566 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_694 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_834 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_514 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_438 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5330_ _5330_/A _5330_/B clb_input[10] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_141_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_696 VGND VPWR sky130_fd_sc_hd__decap_12
X_5261_ _4549_/Y _4553_/Y _5261_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_142_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_346 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_901 VGND VPWR sky130_fd_sc_hd__decap_12
X_7000_ _6979_/A _6981_/A _7000_/C _6999_/Y _7000_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4212_ _4191_/X _7016_/B _4211_/X _4213_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_123_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_5192_ _5192_/A1 _5178_/X _5194_/B _5191_/X _5192_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_95_241 VGND VPWR sky130_fd_sc_hd__decap_3
X_4143_ _4133_/X _4142_/X _4124_/X _4143_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_56_606 VGND VPWR sky130_fd_sc_hd__decap_12
X_4074_ _4074_/A _4074_/B _4074_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_95_252 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_466 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_458 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_436 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_193 VGND VPWR sky130_fd_sc_hd__decap_8
X_7764_ _7764_/D _7764_/Q _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XPHY_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6715_ _6714_/X _6721_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_52_889 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_4976_ _7526_/Q _4976_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_138_906 VGND VPWR sky130_fd_sc_hd__fill_1
X_7695_ _7695_/D _7695_/Q _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_3927_ _3919_/X conf_hcb[57] _3927_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_149_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_438 VGND VPWR sky130_fd_sc_hd__decap_8
X_3858_ _7730_/Q _3858_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6646_ _6654_/A _4058_/X _6647_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_6577_ _6184_/A _6529_/X _6577_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3789_ _3779_/X _6109_/A _3770_/X _3789_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_118_685 VGND VPWR sky130_fd_sc_hd__decap_12
X_5528_ _5528_/A _5528_/B _5529_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_59_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_666 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5459_ _5458_/Y _5457_/X clb_input[8] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_114_880 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_198 VGND VPWR sky130_fd_sc_hd__decap_12
X_7129_ _7119_/B _7132_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_87_797 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_477 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_469 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_330 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_642 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_355 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_697 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_484 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_266 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_458 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_801 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_834 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_694 VGND VPWR sky130_fd_sc_hd__decap_8
X_4830_ _5991_/B _4831_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_33_344 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_517 VGND VPWR sky130_fd_sc_hd__decap_8
X_4761_ _4771_/A conf_vcb[12] _4761_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_6500_ _6500_/A _6500_/B _6501_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_3712_ _3710_/X _5096_/A _3699_/X _3712_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4692_ _4691_/Y _5637_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_7480_ clb_cin_south clb_cin VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_147_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_246 VGND VPWR sky130_fd_sc_hd__decap_12
X_6431_ _6429_/X _6430_/Y _6432_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_6362_ _6362_/A _6362_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5313_ _5177_/X _5313_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6293_ _6261_/A _6272_/B _6283_/Y _6161_/X _6290_/X _6293_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5244_ _5244_/A _5244_/B _7616_/Q _5243_/X _5244_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5175_ _5175_/A _5175_/B _5244_/A _5244_/B _5176_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_4126_ _4126_/A _4125_/X _4126_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_96_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_296 VGND VPWR sky130_fd_sc_hd__decap_8
X_4057_ _6654_/B _4058_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_71_406 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_672 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_39 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_306 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_642 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_4959_ _4959_/A _4957_/Y _4959_/C _7530_/D VGND VPWR sky130_fd_sc_hd__nor3_4
XFILLER_61_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_7747_ _3767_/Y _5142_/A _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_40_859 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_7678_ _7678_/D _6938_/B _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6629_ _6587_/X _6589_/X _6615_/C _6502_/X _6628_/A _6630_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_153_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_408 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_227 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_699 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_900 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_382 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_789 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_759 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_388 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_769 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_594 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_279 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_452 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_314 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_157 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_146 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_594 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_575 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_778 VGND VPWR sky130_fd_sc_hd__decap_12
X_6980_ _7016_/C _6991_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_65_233 VGND VPWR sky130_fd_sc_hd__decap_8
X_5931_ _5935_/A _5931_/B _5923_/X _5931_/D _5931_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_34_642 VGND VPWR sky130_fd_sc_hd__fill_1
X_5862_ _5862_/A _5833_/A _5862_/C _5862_/D _5862_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4813_ _5970_/C _6001_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7601_ _4589_/Y _5447_/A _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_5793_ _5755_/X _4737_/X _5767_/C _5505_/X _5790_/X _5793_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4744_ _4744_/A conf_vcb[15] _4744_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_358 VGND VPWR sky130_fd_sc_hd__decap_8
X_7532_ _4952_/Y _7532_/Q _7529_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_522 VGND VPWR sky130_fd_sc_hd__decap_12
X_7463_ _7463_/HI north_clb_input[15] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_134_205 VGND VPWR sky130_fd_sc_hd__decap_8
X_4675_ _4675_/A _5637_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6414_ _6417_/A _6424_/B _6413_/Y _6348_/X _6410_/X _6414_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_7394_ _7389_/X _7391_/Y _7392_/X _7393_/Y _7394_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6345_ _6345_/A _6345_/B _6345_/C _6481_/D _6345_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_134_249 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_6276_ _6274_/Y _6275_/X _6256_/A _6276_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_103_603 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_282 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_124 VGND VPWR sky130_fd_sc_hd__decap_8
X_5227_ _5195_/X _5227_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_130_466 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_680 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_425 VGND VPWR sky130_fd_sc_hd__fill_2
X_5158_ _5158_/A east_single_in[0] _5158_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4109_ _4101_/Y _4108_/X _4109_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5089_ _5089_/A _7763_/Q _3693_/A _5100_/D _5089_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_56_233 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_288 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_44 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_37 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_125 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_103 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_645 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_511 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_169 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_656 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_667 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_791 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_96 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_306 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_0_0_clk clkbuf_1_0_0_clk/X clkbuf_3_1_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_153_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_691 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_789 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_589 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_770 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_623 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_494 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_391 VGND VPWR sky130_fd_sc_hd__decap_12
X_4460_ _7309_/A _7291_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_116_238 VGND VPWR sky130_fd_sc_hd__decap_8
X_4391_ _4376_/X _7162_/A _4390_/X _4392_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_7_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_6130_ _7737_/Q _6179_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_124_293 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_455 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_617 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_306 VGND VPWR sky130_fd_sc_hd__decap_4
X_6061_ _6061_/A south_single_in[0] _6061_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_78_380 VGND VPWR sky130_fd_sc_hd__decap_12
X_5012_ _4905_/X _5012_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_94_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_767 VGND VPWR sky130_fd_sc_hd__fill_1
X_6963_ _6965_/B _6837_/X _6965_/A _6922_/B _6963_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_81_556 VGND VPWR sky130_fd_sc_hd__fill_1
X_6894_ _6890_/X _6891_/Y _6892_/X _6893_/Y _6896_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_5914_ _5914_/A _5914_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5845_ _5856_/C _5873_/B _5832_/X _5834_/X _5845_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5776_ _5762_/B _5776_/B _5777_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_148_886 VGND VPWR sky130_fd_sc_hd__decap_12
X_4727_ _4727_/A _4726_/X _7576_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7515_ _7515_/D _7515_/Q _7514_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7446_ _7446_/HI east_clb_input[22] VGND VPWR sky130_fd_sc_hd__conb_1
X_4658_ _4658_/A _4657_/X _4658_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_761 VGND VPWR sky130_fd_sc_hd__fill_2
X_7377_ _7353_/B _5924_/A _5925_/A _7374_/A _7377_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_4589_ _4585_/Y _4589_/B _4589_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6328_ _6327_/X _6328_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_131_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_527 VGND VPWR sky130_fd_sc_hd__decap_4
X_6259_ _6259_/A _6260_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_77_818 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_188 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_523 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_575 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_428 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_247 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_589 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_645 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_536 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_772 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_571 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_520 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_296 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_542 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_331 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_545 VGND VPWR sky130_fd_sc_hd__decap_4
X_3960_ _7713_/Q _3960_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_32_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_718 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_91 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_3891_ _3898_/A conf_hcb[63] _3897_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_85_3 VGND VPWR sky130_fd_sc_hd__decap_4
X_5630_ _5773_/A _5622_/A _5635_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_5561_ _5925_/A _5561_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_129_363 VGND VPWR sky130_fd_sc_hd__decap_3
X_7300_ _7291_/A _4464_/A _7301_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4512_ _4103_/A _4512_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5492_ _5488_/X _5489_/X _5490_/X _5491_/Y _5492_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_145_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_355 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_333 VGND VPWR sky130_fd_sc_hd__decap_3
X_7231_ _7230_/X _7234_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_528 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_517 VGND VPWR sky130_fd_sc_hd__fill_2
X_4443_ _7626_/Q _7290_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_113_742 VGND VPWR sky130_fd_sc_hd__decap_8
X_7162_ _7162_/A _7162_/B _7162_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4374_ _4384_/A conf_vcb[82] _4379_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_550 VGND VPWR sky130_fd_sc_hd__decap_8
X_6113_ _7737_/Q _7736_/Q _7739_/Q _6113_/D _6114_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_59_807 VGND VPWR sky130_fd_sc_hd__decap_12
X_7093_ _7093_/A _7094_/B _7093_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_140_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_317 VGND VPWR sky130_fd_sc_hd__fill_1
X_6044_ _7528_/Q _4970_/Y north_single_in[3] _6042_/X _6043_/X east_single_out[3]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_112_296 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_553 VGND VPWR sky130_fd_sc_hd__decap_12
X_6946_ _6946_/A _6946_/B _6946_/C _6817_/D _6946_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_82_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_792 VGND VPWR sky130_fd_sc_hd__fill_1
X_6877_ _6855_/A _6879_/B _6889_/C _6809_/X _6851_/X _6877_/X VGND VPWR sky130_fd_sc_hd__o32a_4
Xpsn_inst_psn_buff_6 _5211_/D _5111_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5828_ _5873_/A _4773_/A _5829_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5759_ _5759_/A _5759_/B _4724_/Y _5760_/B VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_136_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_7429_ _7429_/HI clb_output_west[5] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_123_528 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_539 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_357 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_583 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_648 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_770 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_497 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_664 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_325 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_228 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_745 VGND VPWR sky130_fd_sc_hd__decap_12
X_4090_ _4090_/A _4091_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_789 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_361 VGND VPWR sky130_fd_sc_hd__decap_4
X_6800_ _4107_/X _6800_/B _6812_/C _6664_/D _6832_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_64_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_4992_ _4974_/A conf_sb[13] _4992_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_149_403 VGND VPWR sky130_fd_sc_hd__decap_12
X_3943_ _3921_/X _6397_/B _3942_/X _3944_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6731_ _6759_/A _6726_/B _6730_/X _6664_/D _6731_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_32_740 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_6662_ _6662_/A _6662_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3874_ _3869_/Y _3874_/B _3874_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_118_801 VGND VPWR sky130_fd_sc_hd__decap_8
X_5613_ _5635_/B _5613_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6593_ _6590_/X _6592_/X _6594_/A VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_13 _6732_/A _7057_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_46 _6602_/A _6470_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_333 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_35 psn_inst_psn_buff_35/A psn_inst_psn_buff_35/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_24 psn_inst_psn_buff_27/X psn_inst_psn_buff_4/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5544_ vertical_global[2] _5544_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_141 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_57 _6111_/X psn_inst_psn_buff_57/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_68 psn_inst_psn_buff_68/A psn_inst_psn_buff_66/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5475_ _5509_/C _5483_/B VGND VPWR sky130_fd_sc_hd__inv_8
Xpsn_inst_psn_buff_79 psn_inst_psn_buff_79/A psn_inst_psn_buff_79/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4426_ _4436_/A conf_vcb[72] _4426_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7214_ _7214_/A _7214_/B _7214_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_7145_ _7115_/X _7145_/B _7145_/C _7145_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_100_200 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_261 VGND VPWR sky130_fd_sc_hd__decap_12
X_4357_ _4357_/A _4356_/X _4357_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_59_626 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_103 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_745 VGND VPWR sky130_fd_sc_hd__fill_2
X_4288_ _4288_/A _4288_/B _4288_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7076_ _7071_/X _7073_/Y _7074_/X _7075_/Y _7076_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_58_147 VGND VPWR sky130_fd_sc_hd__decap_6
X_6027_ _6025_/Y _6026_/X _6028_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_74_618 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_350 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_309 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_692 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_191 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_386 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_6929_ _6965_/A _6965_/B _6921_/A _6921_/B _6929_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_14_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_740 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_581 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_480 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_86 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_196 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_325 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_666 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_445 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_618 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_865 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_345 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_559 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_592 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_174 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_163 VGND VPWR sky130_fd_sc_hd__decap_8
X_5260_ _4532_/Y _5259_/X _5260_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_142_678 VGND VPWR sky130_fd_sc_hd__decap_12
X_4211_ _4091_/A _4211_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_913 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_401 VGND VPWR sky130_fd_sc_hd__decap_12
X_5191_ _4520_/Y _5190_/X _5191_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_110_520 VGND VPWR sky130_fd_sc_hd__decap_8
X_4142_ _6879_/B _4142_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4073_ _4069_/X _6759_/A _4060_/X _4074_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_110_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_275 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_478 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_618 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_662 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_651 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_7763_ _7763_/D _7763_/Q _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4975_ _4925_/X _4975_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3926_ _3920_/Y _3926_/B _7719_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6714_ _6722_/A _4087_/X _6714_/X VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7694_ _4074_/Y _7694_/Q _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_137_428 VGND VPWR sky130_fd_sc_hd__decap_6
X_3857_ _3846_/A conf_hcb[69] _3860_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6645_ _4035_/Y _6645_/B _6708_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_20_776 VGND VPWR sky130_fd_sc_hd__decap_12
X_6576_ _6576_/A _6529_/X _6576_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_118_642 VGND VPWR sky130_fd_sc_hd__decap_4
X_3788_ _6102_/B _6109_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5527_ _5526_/X _5470_/X _5528_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_145_472 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_697 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_209 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5458_ _7223_/A _5457_/B _5458_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4409_ _4405_/A conf_vcb[75] _4414_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_120_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_306 VGND VPWR sky130_fd_sc_hd__decap_8
X_5389_ _5388_/Y _5390_/B _5389_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_7128_ _7124_/X _7125_/X _7126_/X _7127_/Y _7128_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_115_66 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_15 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_467 VGND VPWR sky130_fd_sc_hd__fill_1
X_7059_ _7037_/B _6803_/X _6804_/X _7054_/X _7059_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_101_597 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_459 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_640 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_353 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_98 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_345 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_518 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_494 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_818 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_441 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_306 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_6_0_clk clkbuf_5_7_0_clk/A _7539_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_120_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_264 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_253 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_12 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_810 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_289 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_429 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_813 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_334 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_846 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_367 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_581 VGND VPWR sky130_fd_sc_hd__decap_3
X_4760_ _4733_/A _4771_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3711_ _7759_/Q _5096_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4691_ _4691_/A _4691_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6430_ _6389_/A _6428_/B _6419_/Y _6362_/X _6427_/X _6430_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_146_258 VGND VPWR sky130_fd_sc_hd__decap_12
X_6361_ _6357_/X _6358_/Y _6359_/X _6360_/Y _6364_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_115_601 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_280 VGND VPWR sky130_fd_sc_hd__decap_3
X_5312_ _5280_/X _5283_/Y _5312_/C _5312_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_6292_ _6287_/X _6289_/Y _6290_/X _6291_/Y _6292_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_102_317 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_518 VGND VPWR sky130_fd_sc_hd__fill_1
X_5243_ _5164_/X vertical_global[0] _5175_/A _5243_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_114_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_754 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_231 VGND VPWR sky130_fd_sc_hd__decap_8
X_5174_ _5174_/A _5174_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4125_ _4104_/X _4123_/X _4124_/X _4125_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_57_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_757 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_117 VGND VPWR sky130_fd_sc_hd__decap_12
X_4056_ _4052_/A conf_hcb[35] _4056_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_83_256 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_307 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_481 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_687 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_68 VGND VPWR sky130_fd_sc_hd__fill_1
X_4958_ _4958_/A conf_sb[21] _4959_/C VGND VPWR sky130_fd_sc_hd__nor2_4
X_7746_ _7746_/D _7746_/Q _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_12_529 VGND VPWR sky130_fd_sc_hd__decap_8
X_3909_ _6315_/B _6332_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_138_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_203 VGND VPWR sky130_fd_sc_hd__decap_12
X_7677_ _4177_/Y _6930_/A _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4889_ _4843_/A _4889_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6628_ _6628_/A _6628_/B _6628_/C _6630_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_137_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_450 VGND VPWR sky130_fd_sc_hd__decap_8
X_6559_ _6554_/X _6556_/Y _6557_/X _6558_/Y _6559_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_134_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_483 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_472 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_291 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_280 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_645 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_626 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_437 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_643 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_203 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_103 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_337 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_169 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_757 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_908 VGND VPWR sky130_fd_sc_hd__decap_8
X_5930_ _5930_/A _5900_/X _5927_/X _5931_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_80_215 VGND VPWR sky130_fd_sc_hd__decap_8
X_5861_ _5873_/A _5867_/B _5857_/A _5857_/B _5861_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7600_ _4594_/Y _5395_/C _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4812_ _4807_/A conf_vcb[3] _4816_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5792_ _5787_/X _5789_/Y _5790_/X _5791_/Y _5792_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4743_ _4740_/Y _4742_/X _7573_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7531_ _7531_/D _4954_/A _7529_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7462_ _7462_/HI north_clb_input[14] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_534 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_6413_ _6413_/A _6413_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4674_ _4651_/X conf_vcb[28] _4674_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_7393_ _7397_/A _7396_/D _7374_/X _7329_/D _7393_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6344_ _6053_/X _6481_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_6275_ _6263_/B _6138_/X _6140_/X _6270_/X _6275_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_88_348 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_337 VGND VPWR sky130_fd_sc_hd__fill_2
X_5226_ _5205_/X _5214_/X _5215_/X _5225_/Y _5226_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_69_540 VGND VPWR sky130_fd_sc_hd__decap_8
X_5157_ _5153_/Y _4385_/Y _5141_/X _5154_/X _5156_/X south_single_out[2] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_96_381 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_510 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_201 VGND VPWR sky130_fd_sc_hd__decap_12
X_4108_ _4104_/X _4107_/X _4091_/X _4108_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5088_ _5087_/Y _5130_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_57_757 VGND VPWR sky130_fd_sc_hd__decap_12
X_4039_ _4052_/A conf_hcb[38] _4039_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_37_492 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_49 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_115 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_440 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_104 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_613 VGND VPWR sky130_fd_sc_hd__decap_8
X_7729_ _3868_/Y _6253_/C _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XPHY_159 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_534 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_504 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_431 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_412 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_478 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_456 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_860 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_489 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_554 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_245 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_565 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_546 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_654 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_602 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_679 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_718 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_886 VGND VPWR sky130_fd_sc_hd__decap_12
X_4390_ _4417_/A _4390_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_124_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_250 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_401 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_613 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_123 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_776 VGND VPWR sky130_fd_sc_hd__decap_12
X_6060_ _6058_/A _7511_/Q _6219_/D _6058_/X _6059_/X east_single_out[1] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_629 VGND VPWR sky130_fd_sc_hd__decap_12
X_5011_ _7518_/Q _6064_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_39_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_392 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_908 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_576 VGND VPWR sky130_fd_sc_hd__decap_4
X_6962_ _7680_/Q _6927_/Y _6961_/X _6962_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_19_470 VGND VPWR sky130_fd_sc_hd__decap_12
X_6893_ _6889_/A _6858_/X _6881_/A _6828_/D _6893_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5913_ _5900_/X _5914_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5844_ _5844_/A _5856_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_613 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_123 VGND VPWR sky130_fd_sc_hd__decap_12
X_5775_ _4741_/A _4746_/X _5774_/X _5775_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7514_ _5032_/Y _7514_/Q _7514_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4726_ _4708_/X _4724_/Y _4725_/X _4726_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_148_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_206 VGND VPWR sky130_fd_sc_hd__decap_8
X_7445_ _7445_/HI east_clb_input[21] VGND VPWR sky130_fd_sc_hd__conb_1
X_4657_ _4654_/X _4656_/X _4642_/X _4657_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7376_ _7376_/A _7376_/B _7376_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_150_507 VGND VPWR sky130_fd_sc_hd__decap_12
X_6327_ _6327_/A _6327_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_116_784 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_401 VGND VPWR sky130_fd_sc_hd__decap_8
X_4588_ _4570_/X _5404_/C _4587_/X _4589_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6258_ _6258_/A _6261_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_103_456 VGND VPWR sky130_fd_sc_hd__decap_12
X_6189_ _6251_/A _6187_/B _6189_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_103_489 VGND VPWR sky130_fd_sc_hd__decap_12
X_5209_ _7643_/Q south_single_in[2] _4351_/Y _5209_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_57_510 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_874 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_462 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_410 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_668 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_367 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_518 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_209 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_605 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_318 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_583 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_554 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_484 VGND VPWR sky130_fd_sc_hd__decap_8
X_3890_ _3832_/A _3898_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_78_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5560_ _5924_/A _5560_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4511_ _4511_/A conf_vcb[57] _4518_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5491_ _5491_/A _4625_/Y _5491_/C _5571_/D _5491_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4442_ _4436_/A conf_vcb[69] _4446_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7230_ _7229_/X _7230_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_7_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_367 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_389 VGND VPWR sky130_fd_sc_hd__decap_8
X_7161_ _7181_/A _4410_/A _7161_/C _4401_/Y _7162_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_4373_ _4425_/A _4384_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6112_ _6112_/A _6112_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_101_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_819 VGND VPWR sky130_fd_sc_hd__decap_6
X_7092_ _6789_/X _7050_/A _7091_/X _7093_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_100_426 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_616 VGND VPWR sky130_fd_sc_hd__decap_8
X_6043_ _4970_/A _5296_/X _4965_/Y _6043_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_100_459 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_159 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_565 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_6945_ _6915_/A _6915_/B _6917_/X _6941_/B _6945_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_81_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_410 VGND VPWR sky130_fd_sc_hd__decap_4
X_6876_ _6855_/A _6857_/A _6875_/Y _6876_/D _6876_/X VGND VPWR sky130_fd_sc_hd__or4_4
Xpsn_inst_psn_buff_7 _5211_/D _5119_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5827_ _5827_/A _5827_/B _5827_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_10_627 VGND VPWR sky130_fd_sc_hd__decap_12
X_5758_ _5794_/D _5759_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4709_ _5679_/A _5706_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_7428_ _7428_/HI clb_output_west[4] VGND VPWR sky130_fd_sc_hd__conb_1
X_5689_ _5681_/A _5681_/B _5689_/C _5915_/D _5689_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_135_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_410 VGND VPWR sky130_fd_sc_hd__decap_12
X_7359_ _7396_/C _7370_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_253 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_115 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_351 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_129 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_310 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_505 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_549 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_676 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_592 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_402 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_757 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_671 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_833 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_91 VGND VPWR sky130_fd_sc_hd__fill_1
X_6730_ _6729_/X _6730_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_63_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_376 VGND VPWR sky130_fd_sc_hd__decap_8
X_4991_ _4987_/Y _4991_/B _4991_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3942_ _3973_/A _3942_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_149_415 VGND VPWR sky130_fd_sc_hd__decap_12
X_6661_ _7697_/Q _4058_/A _6662_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_3873_ _3863_/X _6272_/B _3854_/X _3874_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_32_785 VGND VPWR sky130_fd_sc_hd__decap_8
X_6592_ _6614_/A _6582_/B _6592_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5612_ _5611_/X _5615_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5543_ _5536_/X _5546_/A _5543_/X VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_36 _6403_/X _6606_/A1 VGND VPWR sky130_fd_sc_hd__buf_8
Xpsn_inst_psn_buff_14 _6401_/A _7119_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_47 _5222_/X psn_inst_psn_buff_44/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_25 psn_inst_psn_buff_25/A psn_inst_psn_buff_5/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5474_ _5474_/A _5523_/A VGND VPWR sky130_fd_sc_hd__inv_8
Xpsn_inst_psn_buff_69 psn_inst_psn_buff_69/A _5192_/A1 VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_58 psn_inst_psn_buff_61/X psn_inst_psn_buff_53/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_4425_ _4425_/A _4436_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7213_ _4412_/X _6023_/X _7191_/C _7173_/A _7214_/B VGND VPWR sky130_fd_sc_hd__a211o_4
X_7144_ _7144_/A _7144_/B _7145_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_98_240 VGND VPWR sky130_fd_sc_hd__decap_12
X_4356_ _4350_/X _5207_/A _4341_/X _4356_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_98_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_212 VGND VPWR sky130_fd_sc_hd__fill_2
X_4287_ _4281_/X _5059_/A _4272_/X _4288_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_86_457 VGND VPWR sky130_fd_sc_hd__fill_1
X_7075_ _7075_/A _7075_/B _7072_/A _6423_/A _7075_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6026_ _5990_/A _5990_/B _7215_/C _5979_/X _6026_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_104_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_68 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_535 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_855 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_825 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_6928_ _6930_/A _6965_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_81_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_184 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6859_ _6859_/A _6858_/X _6859_/C _6860_/B VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_80_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_251 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_824 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_468 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_446 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_492 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_632 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_142 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_164 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_145_86 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_535 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_803 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_387 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_186 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_123 VGND VPWR sky130_fd_sc_hd__decap_8
X_4210_ _7012_/B _7016_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_79_91 VGND VPWR sky130_fd_sc_hd__decap_6
X_5190_ _5925_/A _5190_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_150_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_733 VGND VPWR sky130_fd_sc_hd__decap_8
X_4141_ _4141_/A _6879_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_110_576 VGND VPWR sky130_fd_sc_hd__decap_4
X_4072_ _4072_/A _6759_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_788 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_855 VGND VPWR sky130_fd_sc_hd__decap_4
X_7762_ _7762_/D _3693_/A _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_858 VGND VPWR sky130_fd_sc_hd__decap_12
X_4974_ _4974_/A conf_sb[17] _4978_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_36_398 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_335 VGND VPWR sky130_fd_sc_hd__decap_8
X_3925_ _3921_/X _6400_/A _3912_/X _3926_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6713_ _4064_/Y _6713_/B _6776_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_7693_ _7693_/D _4076_/A _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_149_245 VGND VPWR sky130_fd_sc_hd__decap_12
X_6644_ _7697_/Q _6654_/B _6644_/C _6644_/D _6645_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_3856_ _3856_/A _3855_/X _3856_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6575_ _6458_/X _6533_/A _6574_/X _6576_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_3787_ _3787_/A conf_hcb[81] _3790_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_788 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_153 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_816 VGND VPWR sky130_fd_sc_hd__decap_8
X_5526_ _6031_/A _5526_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_484 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_101 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_5457_ _5457_/A _5457_/B _5457_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_132_145 VGND VPWR sky130_fd_sc_hd__decap_8
X_4408_ _4405_/Y _4407_/X _7633_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_59_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_178 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_12 VGND VPWR sky130_fd_sc_hd__decap_12
X_5388_ _5171_/X _5344_/X _5387_/X _5388_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_7127_ _7127_/A _7127_/B _7127_/C _6053_/X _7127_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_101_510 VGND VPWR sky130_fd_sc_hd__decap_8
X_4339_ _4344_/A conf_vcb[89] _4339_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7058_ _7047_/X _7058_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_115_89 VGND VPWR sky130_fd_sc_hd__decap_8
X_6009_ _5976_/A _5993_/B _6008_/Y _5865_/X _6005_/X _6009_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_86_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_449 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_376 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_666 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_145_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_453 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_906 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_405 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_224 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_24 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_460 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_655 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_3710_ _3733_/A _3710_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4690_ _4696_/A conf_vcb[25] _4690_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6360_ _3895_/X _6322_/X _6336_/A _6360_/D _6360_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_60_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_270 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_473 VGND VPWR sky130_fd_sc_hd__decap_12
X_5311_ _5311_/A _5310_/Y _5312_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_154_292 VGND VPWR sky130_fd_sc_hd__decap_12
X_6291_ _6272_/A _6260_/A _6272_/C west_double_out[1] _6291_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5242_ _5241_/X _4497_/Y _5242_/C _5242_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_69_733 VGND VPWR sky130_fd_sc_hd__fill_1
X_5173_ _5173_/A _5174_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_111_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_351 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_340 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_703 VGND VPWR sky130_fd_sc_hd__decap_4
X_4124_ _4091_/A _4124_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_766 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_276 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_4055_ _4055_/A _4054_/X _4055_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_92_780 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_803 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_308 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4957_ cset _7530_/Q _4957_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7745_ _3776_/Y _6089_/B _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_699 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_3908_ _3898_/A conf_hcb[60] _3908_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7676_ _4184_/Y _6923_/B _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4888_ _4885_/Y _4887_/X _7545_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6627_ _6627_/A _6627_/B _6628_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_137_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_3839_ _3833_/Y _3839_/B _3839_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6558_ _6558_/A _6558_/B _6555_/A _6558_/D _6558_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6489_ _6452_/X _3962_/X _6488_/Y _6420_/X _6485_/X _6489_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_105_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_5509_ _5503_/A _5503_/B _5509_/C _5508_/X _5509_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_126_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_638 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_104 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_405 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_706 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_449 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_493 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_335 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_806 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_817 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_154 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_839 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_699 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_349 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_237 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_440 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_476 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_649 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_126 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_693 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_725 VGND VPWR sky130_fd_sc_hd__decap_8
X_5860_ _5869_/A _5869_/B _5862_/C _5859_/X _5856_/X _5860_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_33_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_482 VGND VPWR sky130_fd_sc_hd__decap_12
X_4811_ _4807_/Y _4810_/X _7561_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_34_655 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_496 VGND VPWR sky130_fd_sc_hd__decap_8
X_5791_ _4730_/X _5794_/D _5782_/C _5791_/D _5791_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_7530_ _7530_/D _7530_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4742_ _4735_/X _4741_/Y _4725_/X _4742_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7461_ _7461_/HI north_clb_input[13] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_546 VGND VPWR sky130_fd_sc_hd__decap_3
X_4673_ _4669_/Y _4673_/B _4673_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_135_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_6412_ _6408_/X _6409_/X _6410_/X _6411_/Y _6412_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_134_218 VGND VPWR sky130_fd_sc_hd__decap_12
X_7392_ _7407_/A _4492_/X _7396_/C _7392_/D _7392_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6343_ _3894_/Y _6321_/A _6330_/X _6343_/D _6343_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_89_806 VGND VPWR sky130_fd_sc_hd__decap_4
X_6274_ _6264_/B _6274_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5225_ _5213_/X _5225_/B _5225_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_130_457 VGND VPWR sky130_fd_sc_hd__fill_1
X_5156_ _4377_/Y _7637_/Q _5155_/X _5156_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_84_500 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_574 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_4107_ _4106_/Y _4107_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5087_ clb_output[1] _5087_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_57_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_4038_ _3950_/A _4052_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_71_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_611 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_116 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_452 VGND VPWR sky130_fd_sc_hd__decap_6
X_5989_ _7558_/Q _5990_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_80_783 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_149 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_5_5_0_clk clkbuf_5_5_0_clk/A _7670_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_24_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_7728_ _3874_/Y _6259_/A _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_12_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_579 VGND VPWR sky130_fd_sc_hd__fill_1
X_7659_ _7659_/D _5067_/B _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_153_516 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_424 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_338 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_468 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_872 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_850 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_500 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_577 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_739 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_471 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_794 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_524 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_861 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_568 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_505 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_281 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_413 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_625 VGND VPWR sky130_fd_sc_hd__fill_1
X_5010_ _5015_/A conf_sb[9] _5014_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_544 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_514 VGND VPWR sky130_fd_sc_hd__decap_8
X_6961_ _6961_/A _6961_/B _6961_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_19_482 VGND VPWR sky130_fd_sc_hd__decap_6
X_6892_ _6883_/A _6867_/B _6855_/X _6889_/B _6892_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5912_ _5912_/A _5912_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_62_750 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_5843_ _5832_/X _5834_/X _5862_/C _5915_/D _5884_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_148_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_5774_ _7572_/Q _5560_/X _5561_/X _5770_/X _5774_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_7513_ _7513_/D _5034_/A _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_354 VGND VPWR sky130_fd_sc_hd__decap_12
X_4725_ _4725_/A _4725_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7444_ _7444_/HI east_clb_input[20] VGND VPWR sky130_fd_sc_hd__conb_1
X_4656_ _4655_/Y _4656_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7375_ _7397_/A _7392_/D _7374_/X _5068_/Y _7375_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4587_ _4499_/A _4587_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6326_ _6324_/B _6325_/X _6327_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_115_240 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_210 VGND VPWR sky130_fd_sc_hd__decap_4
X_6257_ _6257_/A _6258_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_103_468 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_446 VGND VPWR sky130_fd_sc_hd__fill_1
X_6188_ _6642_/A _6251_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5208_ _5207_/A east_clb_output[0] _5208_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_123_12 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_853 VGND VPWR sky130_fd_sc_hd__fill_1
X_5139_ _5123_/A _7640_/Q _5138_/X _5139_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_85_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_227 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_452 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_496 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_499 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_741 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_560 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_700 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_221 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_135 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_490 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_138 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_127 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_812 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_566 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_780 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_739 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_441 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_343 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_691 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4510_ _4510_/A _4511_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5490_ _5490_/A _7594_/Q _5478_/X _5495_/B _5490_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4441_ _4441_/A _4440_/X _4441_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7160_ _7159_/Y _7160_/B north_clb_input[0] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_125_582 VGND VPWR sky130_fd_sc_hd__decap_8
X_6111_ _6107_/Y _3792_/Y _6102_/X _6108_/X _6110_/X _6111_/X VGND VPWR sky130_fd_sc_hd__a32o_4
X_4372_ _4372_/A _4425_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_221 VGND VPWR sky130_fd_sc_hd__fill_1
X_7091_ _7050_/Y _7091_/B _7091_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_79_680 VGND VPWR sky130_fd_sc_hd__decap_8
X_6042_ _4970_/Y _6038_/Y _6042_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_39_522 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_864 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_6944_ _6946_/A _6946_/B _6946_/C _6677_/X _6940_/X _6944_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_35_761 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_6875_ _6807_/A1 _6872_/Y _6874_/Y _6875_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_35_794 VGND VPWR sky130_fd_sc_hd__decap_6
Xpsn_inst_psn_buff_8 _5211_/D _5075_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5826_ _5844_/A _5826_/B _7570_/Q _5857_/B _5827_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_50_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_639 VGND VPWR sky130_fd_sc_hd__fill_2
X_5757_ _4736_/A _5794_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_136_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_4708_ _4735_/A _4708_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_147_184 VGND VPWR sky130_fd_sc_hd__fill_2
X_7427_ _7427_/HI clb_output_west[3] VGND VPWR sky130_fd_sc_hd__conb_1
X_5688_ _5687_/Y _5689_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_151_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_379 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_4639_ _4645_/A conf_vcb[34] _4639_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_118_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_422 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_7358_ _7357_/X _7396_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_2_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_349 VGND VPWR sky130_fd_sc_hd__decap_12
X_6309_ _6308_/Y _6309_/B _6309_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_7289_ _7309_/A _4464_/A _7625_/Q _7289_/D _7290_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_134_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_265 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_628 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_48 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_609 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_706 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_455 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_632 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_571 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_563 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_714 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_436 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_661 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_330 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_547 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_783 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_4990_ _4975_/X _4988_/Y _4989_/X _4991_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_3941_ _3793_/A _3973_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_17_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_6660_ _6700_/A _6700_/B _6652_/A _6652_/B _6660_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3872_ _6290_/D _6272_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_90_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_764 VGND VPWR sky130_fd_sc_hd__decap_8
X_6591_ _6602_/B _6590_/X _6591_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5611_ _5635_/A _5611_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_5542_ _5539_/X _5541_/X _4640_/Y _5546_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_129_184 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_15 _6401_/A _6100_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_37 psn_inst_psn_buff_57/X _6403_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_26 psn_inst_psn_buff_26/A psn_inst_psn_buff_9/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_806 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_48 psn_inst_psn_buff_52/X psn_inst_psn_buff_2/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5473_ _5473_/A _5474_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_59 psn_inst_psn_buff_59/A psn_inst_psn_buff_59/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_187 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_176 VGND VPWR sky130_fd_sc_hd__decap_8
X_4424_ _4424_/A _4423_/X _4424_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7212_ _4389_/A _7178_/X _7212_/C _7214_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_132_349 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_742 VGND VPWR sky130_fd_sc_hd__decap_12
X_7143_ _7104_/X _7106_/X _7134_/Y _6362_/A _7140_/X _7144_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4355_ _7643_/Q _5207_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_252 VGND VPWR sky130_fd_sc_hd__fill_2
X_7074_ _7074_/A _7074_/B _7041_/X _4229_/A _7074_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_113_596 VGND VPWR sky130_fd_sc_hd__decap_12
X_4286_ _5056_/A _5059_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_101_769 VGND VPWR sky130_fd_sc_hd__decap_8
X_6025_ _6022_/X _6024_/X _6025_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_100_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_672 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_503 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_867 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_547 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_152 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6927_ _6927_/A _4171_/X _6922_/A _6795_/D _6927_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_23_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_580 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_68 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6858_ _6889_/B _6858_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_5809_ _5809_/A _5810_/B _5809_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_6789_ horizontal_global[2] _6789_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_109_836 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_15 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_154 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_37 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_113 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_541 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_252 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_791 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_603 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_817 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_440 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_828 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_305 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_701 VGND VPWR sky130_fd_sc_hd__fill_1
X_4140_ _6857_/A _4141_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_95_233 VGND VPWR sky130_fd_sc_hd__decap_8
X_4071_ _4070_/X _4072_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_95_91 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_675 VGND VPWR sky130_fd_sc_hd__decap_12
X_7761_ _3701_/Y _7761_/Q _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4973_ _4922_/X _4974_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3924_ _6417_/A _6400_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6712_ _4082_/A _4086_/A _7694_/Q _6712_/D _6713_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_7692_ _4084_/Y _4082_/A _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6643_ _6642_/Y _6641_/X clb_input[0] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_32_572 VGND VPWR sky130_fd_sc_hd__decap_8
X_3855_ _3834_/X _6232_/B _3854_/X _3855_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6574_ _6533_/Y _6574_/B _6574_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_3786_ _3783_/Y _3786_/B _3786_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_117_132 VGND VPWR sky130_fd_sc_hd__decap_12
X_5525_ _5525_/A _5470_/X _5528_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_117_165 VGND VPWR sky130_fd_sc_hd__fill_1
X_5456_ _5455_/Y _5456_/B _5457_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4407_ _4400_/X _7163_/A _4390_/X _4407_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_99_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_403 VGND VPWR sky130_fd_sc_hd__decap_8
X_5387_ _5345_/Y _5386_/X _5387_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_115_24 VGND VPWR sky130_fd_sc_hd__decap_12
X_7126_ _7132_/A _7124_/B _7126_/C _7101_/B _7126_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4338_ _4335_/Y _4338_/B _7647_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_59_414 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_566 VGND VPWR sky130_fd_sc_hd__fill_1
X_4269_ _7661_/Q _4270_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_86_266 VGND VPWR sky130_fd_sc_hd__decap_8
X_7057_ _7057_/A _7079_/C _7062_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_47_609 VGND VPWR sky130_fd_sc_hd__fill_1
X_6008_ _6008_/A _6008_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_28_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_506 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_870 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_474 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_699 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_734 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_222 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_789 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_94 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_645 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_678 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_667 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_166 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_463 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_614 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_102 VGND VPWR sky130_fd_sc_hd__decap_12
X_6290_ _6269_/A _3882_/A _6258_/A _6290_/D _6290_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_53_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5310_ _5280_/C _5280_/D _5301_/Y north_double_out[2] _5307_/X _5310_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_142_444 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_433 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_281 VGND VPWR sky130_fd_sc_hd__decap_12
X_5241_ _5177_/X _5179_/X _5180_/Y _5240_/Y _5241_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_111_820 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_211 VGND VPWR sky130_fd_sc_hd__decap_3
X_5172_ _5175_/A _5164_/X _5170_/C _5173_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4123_ _6811_/D _4123_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_542 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_907 VGND VPWR sky130_fd_sc_hd__decap_8
X_4054_ _4040_/X _6654_/A _4031_/X _4054_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_83_203 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_770 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_815 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_280 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_309 VGND VPWR sky130_fd_sc_hd__decap_3
X_7744_ _7744_/D _7744_/Q _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_101_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_870 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_881 VGND VPWR sky130_fd_sc_hd__decap_8
X_4956_ _4953_/Y _4956_/B _7531_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_3907_ _3907_/A _3906_/X _7722_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7675_ _7675_/D _4186_/A _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4887_ _4868_/X _4886_/Y _4882_/X _4887_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6626_ _6587_/X _6589_/X _6617_/Y _6362_/X _6623_/X _6627_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_138_739 VGND VPWR sky130_fd_sc_hd__decap_12
X_3838_ _3834_/X _3837_/X _3825_/X _3839_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6557_ _6557_/A _6557_/B _6525_/A _6552_/D _6557_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_20_586 VGND VPWR sky130_fd_sc_hd__decap_12
X_3769_ _7746_/Q _6098_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5508_ _7333_/D _5508_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6488_ _6481_/C _6488_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_105_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_5439_ _5439_/A _5450_/B _5401_/A _5440_/B _5439_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_126_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_127 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_520 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_149 VGND VPWR sky130_fd_sc_hd__decap_4
X_7109_ _7101_/A _7661_/Q _7120_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_102_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_461 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_815 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_86 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_513 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_818 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_520 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_138 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_715 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_406 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_601 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_792 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_494 VGND VPWR sky130_fd_sc_hd__fill_2
X_4810_ _4792_/X _5979_/C _4809_/X _4810_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_92_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_431 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_881 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_306 VGND VPWR sky130_fd_sc_hd__decap_12
X_5790_ _5805_/A _4746_/X _5755_/X _4737_/X _5790_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4741_ _4741_/A _4741_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_119_216 VGND VPWR sky130_fd_sc_hd__decap_12
X_7460_ _7460_/HI north_clb_input[12] VGND VPWR sky130_fd_sc_hd__conb_1
X_4672_ _4654_/X _5607_/A _4671_/X _4673_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_147_569 VGND VPWR sky130_fd_sc_hd__decap_12
X_6411_ _6385_/A _6422_/D _6419_/A _6481_/D _6411_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_30_895 VGND VPWR sky130_fd_sc_hd__decap_12
X_7391_ _7396_/C _7392_/D _7390_/Y _5120_/Y _7387_/X _7391_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6342_ _6345_/A _6345_/B _6345_/C _6146_/X _6316_/B _6342_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_143_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_252 VGND VPWR sky130_fd_sc_hd__decap_8
X_6273_ west_single_out[3] _6283_/A _6278_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_142_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_328 VGND VPWR sky130_fd_sc_hd__decap_8
X_5224_ _5223_/X _5225_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_111_672 VGND VPWR sky130_fd_sc_hd__decap_8
X_5155_ _5155_/A clb_output[2] _5155_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_110_171 VGND VPWR sky130_fd_sc_hd__fill_1
X_4106_ _4106_/A _4106_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5086_ _7764_/Q _5089_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_56_225 VGND VPWR sky130_fd_sc_hd__decap_8
X_4037_ _4037_/A _4037_/B _4037_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_71_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_740 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_106 VGND VPWR sky130_fd_sc_hd__decap_3
X_5988_ _5988_/A _5988_/B _5988_/C _7242_/D _6022_/B VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_139 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_7727_ _3878_/Y _6270_/A _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4939_ _4939_/A _6047_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7658_ _4288_/Y _5056_/A _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_873 VGND VPWR sky130_fd_sc_hd__decap_8
X_6609_ _4013_/Y _7703_/Q _6619_/A _6619_/B _6609_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_153_528 VGND VPWR sky130_fd_sc_hd__fill_1
X_7589_ _4658_/Y _7589_/Q _7574_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_794 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_241 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_589 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_228 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_910 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_40 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_514 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_800 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_547 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_517 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_609 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_158 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_353 VGND VPWR sky130_fd_sc_hd__decap_12
X_6960_ _6921_/A _6921_/B _6946_/C _6833_/X _6929_/X _6961_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_81_504 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_707 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_397 VGND VPWR sky130_fd_sc_hd__fill_1
X_5911_ _5910_/X _5912_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6891_ _6859_/A _4142_/X _6881_/Y _6824_/X _6888_/X _6891_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_62_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_261 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_486 VGND VPWR sky130_fd_sc_hd__decap_12
X_5842_ _5841_/Y _5862_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_61_283 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_272 VGND VPWR sky130_fd_sc_hd__decap_8
X_5773_ _5773_/A _5773_/B _5778_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_148_812 VGND VPWR sky130_fd_sc_hd__decap_12
X_4724_ _7576_/Q _4724_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_21_147 VGND VPWR sky130_fd_sc_hd__decap_12
X_7512_ _5041_/Y _5039_/A _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_30_681 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_692 VGND VPWR sky130_fd_sc_hd__decap_8
X_7443_ _7443_/HI east_clb_input[19] VGND VPWR sky130_fd_sc_hd__conb_1
X_4655_ _7589_/Q _4655_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_116_720 VGND VPWR sky130_fd_sc_hd__decap_8
X_7374_ _7374_/A _7374_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4586_ _5447_/A _5404_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_143_550 VGND VPWR sky130_fd_sc_hd__decap_3
X_6325_ _3905_/Y _6315_/B _6325_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_131_745 VGND VPWR sky130_fd_sc_hd__decap_12
X_6256_ _6256_/A _6283_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6187_ _6186_/X _6187_/B _6190_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_5207_ _5207_/A clb_output[2] _5207_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_123_24 VGND VPWR sky130_fd_sc_hd__decap_12
X_5138_ _4363_/Y _5138_/B _5138_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_72_504 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_5069_ _5068_/Y north_double_out[3] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_72_559 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_902 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_434 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_148_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_528 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_241 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_200 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_797 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_252 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_106 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_570 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_453 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_119 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_108 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_300 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_355 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4440_ _4427_/X _4439_/X _4417_/X _4440_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_550 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_881 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_4371_ _4371_/A _4370_/X _4371_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6110_ _6102_/A _7741_/Q _6109_/X _6110_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_140_531 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_756 VGND VPWR sky130_fd_sc_hd__decap_8
X_7090_ _7090_/A _7090_/B _7091_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_112_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_478 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_467 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_5_4_0_clk clkbuf_5_5_0_clk/A _7545_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_6041_ _4976_/Y _7525_/Q _5296_/X _6039_/X _6040_/X north_single_out[2] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_85_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_718 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_578 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_6943_ _6922_/A _6946_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_26_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_367 VGND VPWR sky130_fd_sc_hd__decap_12
X_6874_ _6872_/Y _6873_/X _6854_/A _6874_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_23_902 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_710 VGND VPWR sky130_fd_sc_hd__decap_8
X_5825_ _6420_/A west_double_out[0] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_62_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_423 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_721 VGND VPWR sky130_fd_sc_hd__decap_8
Xpsn_inst_psn_buff_9 psn_inst_psn_buff_9/A _5067_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_467 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_148_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_478 VGND VPWR sky130_fd_sc_hd__decap_12
X_5756_ _5755_/X _5759_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_135_303 VGND VPWR sky130_fd_sc_hd__fill_2
X_4707_ _4723_/A conf_vcb[22] _4712_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5687_ _5716_/C _5687_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_136_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_7426_ _7426_/HI clb_output_west[2] VGND VPWR sky130_fd_sc_hd__conb_1
X_4638_ _4638_/A _4638_/B _4638_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_151_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_347 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_68 VGND VPWR sky130_fd_sc_hd__fill_1
X_7357_ _7353_/C _7357_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4569_ _4568_/X conf_vcb[47] _4569_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6308_ _6123_/X _6265_/X _6307_/X _6308_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_7288_ _7287_/Y _7286_/X clb_input[14] VGND VPWR sky130_fd_sc_hd__nor2_4
X_6239_ _6239_/A _6239_/B _6239_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_134_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_854 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_331 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_718 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_898 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_529 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_890 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_798 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_303 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_644 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_188 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_199 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_575 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_50 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_106 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_861 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_301 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_887 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_632 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_345 VGND VPWR sky130_fd_sc_hd__fill_1
X_3940_ _6422_/B _6397_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_44_581 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_428 VGND VPWR sky130_fd_sc_hd__decap_12
X_3871_ _3870_/Y _6290_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_31_220 VGND VPWR sky130_fd_sc_hd__decap_12
X_6590_ _6587_/X _6589_/X _6583_/A _6590_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_83_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5610_ _4675_/A _5635_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5541_ _5540_/X _5541_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_303 VGND VPWR sky130_fd_sc_hd__fill_2
Xpsn_inst_psn_buff_16 _5222_/X _5223_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_8_471 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_38 psn_inst_psn_buff_49/X psn_inst_psn_buff_38/X VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_27 psn_inst_psn_buff_27/A psn_inst_psn_buff_27/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_818 VGND VPWR sky130_fd_sc_hd__decap_12
X_7211_ _7211_/A _7210_/Y _7212_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_5472_ _5470_/B _5486_/A _5473_/A VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_49 psn_inst_psn_buff_49/A psn_inst_psn_buff_49/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4423_ _4400_/X _4422_/X _4417_/X _4423_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7142_ _7138_/X _7139_/Y _7140_/X _7141_/Y _7144_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_99_754 VGND VPWR sky130_fd_sc_hd__decap_6
X_4354_ _4368_/A conf_vcb[86] _4357_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_7073_ _7041_/X _7056_/B _7072_/Y _6420_/A _7069_/X _7073_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6024_ _5990_/B _6023_/X _5990_/A _5979_/X _6024_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4285_ _4285_/A conf_vcb[101] _4288_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_104_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_651 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_364 VGND VPWR sky130_fd_sc_hd__fill_2
X_6926_ _6926_/A _6967_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_81_164 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_529 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_175 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6857_ _6857_/A _6889_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_11_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6788_ _6782_/X _6791_/A _6788_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5808_ _5544_/X _5764_/A _5807_/X _5809_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_5739_ _5739_/A _7156_/A _5739_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_109_848 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_49 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_306 VGND VPWR sky130_fd_sc_hd__decap_8
X_7409_ _7367_/Y _7408_/X _7409_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_151_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_136 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_125 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_520 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_553 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_437 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_651 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_429 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_109 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_150 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_301 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_367 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_337 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_359 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_409 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_615 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_497 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_380 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_372 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_361 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_201 VGND VPWR sky130_fd_sc_hd__decap_8
X_4070_ _7694_/Q _4070_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_83_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_481 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_632 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_621 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_687 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_805 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_356 VGND VPWR sky130_fd_sc_hd__decap_8
X_7760_ _3705_/Y _7760_/Q _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4972_ _4969_/Y _4972_/B _4972_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3923_ _6385_/A _6417_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6711_ _6711_/A _6711_/B north_clb_input[7] VGND VPWR sky130_fd_sc_hd__nor2_4
X_7691_ _7691_/D _4086_/A _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6642_ _6642_/A _6642_/B _6642_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3854_ _3854_/A _3854_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_6573_ _6571_/Y _6572_/X _6574_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_3785_ _3779_/X _6102_/A _3770_/X _3786_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_106_807 VGND VPWR sky130_fd_sc_hd__fill_2
X_5524_ _5171_/X _5474_/A _5523_/X _5525_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_5455_ _7220_/A _5405_/X _5455_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_132_125 VGND VPWR sky130_fd_sc_hd__fill_2
X_4406_ _7181_/A _7163_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_132_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_350 VGND VPWR sky130_fd_sc_hd__decap_12
X_7125_ _7127_/A _7127_/B _7127_/C _6145_/Y _7100_/B _7125_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_99_562 VGND VPWR sky130_fd_sc_hd__decap_3
X_5386_ _5386_/A _5385_/X _5386_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_115_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_223 VGND VPWR sky130_fd_sc_hd__fill_2
X_4337_ _4327_/X _4336_/Y _4318_/X _4338_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_59_426 VGND VPWR sky130_fd_sc_hd__fill_1
X_4268_ _4264_/A conf_hcb[0] _4268_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7056_ _7075_/A _7056_/B _7072_/A _6334_/A _7083_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_59_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_589 VGND VPWR sky130_fd_sc_hd__decap_8
X_6007_ _6003_/X _6004_/Y _6005_/X _6006_/X _6007_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4199_ _4198_/Y _7012_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_15_518 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_39 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_473 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_326 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_337 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6909_ _6909_/A _6909_/B _6909_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_24_11 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_623 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_486 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_615 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_103 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_199 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_422 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_440 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_73 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_291 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_626 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_648 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_114 VGND VPWR sky130_fd_sc_hd__decap_12
X_5240_ _5236_/X _5237_/Y _5239_/X _5240_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_142_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_832 VGND VPWR sky130_fd_sc_hd__decap_12
X_5171_ vertical_global[2] _5171_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4122_ _4122_/A _6811_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_554 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_532 VGND VPWR sky130_fd_sc_hd__decap_6
X_4053_ _7697_/Q _6654_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_83_215 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_429 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_248 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_7743_ _3786_/Y _7743_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_24_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_4955_ _4949_/X _6103_/A _4940_/X _4956_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_51_123 VGND VPWR sky130_fd_sc_hd__decap_12
X_3906_ _3892_/X _3905_/Y _3883_/X _3906_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4886_ _5091_/A _4886_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7674_ _7674_/D _6975_/C _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_32_370 VGND VPWR sky130_fd_sc_hd__decap_8
X_6625_ _6621_/X _6622_/Y _6623_/X _6624_/Y _6627_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_3837_ _3836_/Y _3837_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_6556_ _6525_/A _3991_/X _6555_/Y _6420_/X _6552_/X _6556_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_3768_ _3760_/A conf_hcb[85] _3772_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_598 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_5507_ _4630_/Y _4636_/X _5465_/X _5503_/B _5507_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6487_ _6482_/X _6484_/Y _6485_/X _6486_/X _6487_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3699_ _3699_/A _3699_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_121_618 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_5438_ _5401_/A _5417_/B _5412_/C south_double_out[2] _5435_/X _5438_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_133_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_212 VGND VPWR sky130_fd_sc_hd__decap_12
X_5369_ _5337_/A _5353_/B _5368_/Y south_double_out[0] _5365_/X _5369_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
X_7108_ _7119_/B _7110_/A _7156_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_59_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_908 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_7039_ _7069_/A _7074_/B _7040_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_47_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_237 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_911 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_270 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_292 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_220 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_423 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_629 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_662 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_502 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_535 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_760 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_259 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_613 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_454 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_4740_ _4744_/A conf_vcb[16] _4740_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_15_893 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_841 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_228 VGND VPWR sky130_fd_sc_hd__decap_4
X_4671_ _4725_/A _4671_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6410_ _6417_/A _6387_/A _6438_/A _6422_/B _6410_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7390_ _7374_/X _7390_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6341_ _6345_/A _6321_/A _6340_/Y _6336_/Y _6341_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_128_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_6272_ _6272_/A _6272_/B _6272_/C _6210_/D _6272_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_130_426 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_318 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_521 VGND VPWR sky130_fd_sc_hd__decap_8
X_5223_ _5223_/A _5223_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5154_ _5154_/A east_clb_output[0] _5154_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4105_ _4105_/A _4106_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_373 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_362 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_5085_ _7763_/Q _5079_/X _5081_/X _5083_/X _5084_/X _5085_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_56_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_4036_ _4011_/X _4035_/Y _4031_/X _4037_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_112_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_194 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_557 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_440 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_602 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_107 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_668 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VPWR sky130_fd_sc_hd__decap_3
X_5987_ _5987_/A _7242_/D VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_487 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_7726_ _7726_/D _6263_/B _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4938_ _4934_/A conf_sb[25] _4942_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_40_638 VGND VPWR sky130_fd_sc_hd__decap_3
X_4869_ _7549_/Q _4869_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7657_ _7657_/D _4290_/A _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6608_ _4012_/X _4020_/A _6610_/C _6478_/X _6583_/B _6608_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_122_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_896 VGND VPWR sky130_fd_sc_hd__fill_2
X_7588_ _7588_/D _7588_/Q _7574_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_581 VGND VPWR sky130_fd_sc_hd__decap_12
X_6539_ _6558_/A _3991_/X _6555_/A _6601_/D _6539_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_106_401 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_294 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_437 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_513 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_760 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_793 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_624 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_281 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_495 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_262 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_812 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_529 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_426 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_550 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_830 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_811 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_82 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_71 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_365 VGND VPWR sky130_fd_sc_hd__fill_1
X_5910_ _5910_/A _5929_/A _5910_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6890_ _6885_/X _6887_/Y _6888_/X _6889_/Y _6890_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5841_ _5875_/C _5841_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_34_465 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_498 VGND VPWR sky130_fd_sc_hd__fill_2
X_5772_ _4730_/X _4737_/X _5782_/C _5848_/D _5772_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4723_ _4723_/A conf_vcb[19] _4727_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7511_ _7511_/D _7511_/Q _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_7442_ _7442_/HI east_clb_input[18] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_518 VGND VPWR sky130_fd_sc_hd__decap_8
X_4654_ _4735_/A _4654_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_128_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_570 VGND VPWR sky130_fd_sc_hd__decap_8
X_7373_ _7353_/A _4492_/A _7374_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4585_ _4568_/X conf_vcb[44] _4585_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6324_ _6336_/A _6324_/B _6324_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_143_573 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_776 VGND VPWR sky130_fd_sc_hd__decap_8
X_6255_ _6294_/A _3882_/A _6256_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_107_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_638 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_286 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5206_ _7643_/Q east_clb_output[1] _5206_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6186_ _6185_/Y _6183_/X _6186_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_130_289 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_822 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_310 VGND VPWR sky130_fd_sc_hd__decap_8
X_5137_ _7641_/Q _5137_/B _5137_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_123_36 VGND VPWR sky130_fd_sc_hd__decap_12
X_5068_ _4276_/A _5064_/Y _5067_/X _5068_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4019_ _4018_/Y _4020_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_37_281 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_774 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_487 VGND VPWR sky130_fd_sc_hd__fill_1
X_7709_ _3987_/Y _3983_/A _7703_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_32_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_838 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_584 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_321 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_332 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_387 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_516 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_346 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_62 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_367 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_337 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_304 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_389 VGND VPWR sky130_fd_sc_hd__decap_8
X_4370_ _4350_/X _4369_/Y _4365_/X _4370_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_7_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_391 VGND VPWR sky130_fd_sc_hd__decap_12
X_6040_ _7526_/Q east_single_in[2] _4980_/Y _6040_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_85_129 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_803 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_696 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_825 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_505 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_6942_ _6938_/X _6939_/X _6940_/X _6941_/Y _6942_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_82_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_379 VGND VPWR sky130_fd_sc_hd__decap_4
X_6873_ _6851_/B _6803_/X _6804_/X _6868_/X _6873_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_23_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_251 VGND VPWR sky130_fd_sc_hd__decap_12
X_5824_ _3728_/A _5822_/Y _5823_/X _6420_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_50_755 VGND VPWR sky130_fd_sc_hd__decap_8
X_5755_ _5754_/X _5755_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_148_654 VGND VPWR sky130_fd_sc_hd__decap_12
X_5686_ _5685_/X _5728_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4706_ _4733_/A _4723_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7425_ _7425_/HI clb_output_south[7] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_136_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_518 VGND VPWR sky130_fd_sc_hd__fill_1
X_4637_ _4624_/X _4636_/X _4614_/X _4638_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_135_359 VGND VPWR sky130_fd_sc_hd__decap_6
X_7356_ _7356_/A _7363_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4568_ _4510_/A _4568_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_143_392 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_510 VGND VPWR sky130_fd_sc_hd__decap_8
X_6307_ _6266_/Y _6306_/X _6307_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_116_584 VGND VPWR sky130_fd_sc_hd__decap_12
X_7287_ _7287_/A _7226_/X _7287_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4499_ _4499_/A _4499_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6238_ _6196_/X _6198_/X _6221_/Y _6170_/X _6237_/A _6239_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_103_245 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_68 VGND VPWR sky130_fd_sc_hd__fill_1
X_6169_ _6169_/A _6134_/Y _6168_/X _6169_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_85_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_866 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_346 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_700 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_428 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_602 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_624 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_175 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_601 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_359 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_656 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_40 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_895 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_855 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_825 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_899 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_644 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_508 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_593 VGND VPWR sky130_fd_sc_hd__decap_8
X_3870_ _6259_/A _3870_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_31_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_799 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_290 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_142 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_3 VGND VPWR sky130_fd_sc_hd__decap_8
X_5540_ _7589_/Q _5540_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_101 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_849 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_17 psn_inst_psn_buff_44/X _5939_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5471_ _4630_/Y _7592_/Q _5486_/A VGND VPWR sky130_fd_sc_hd__or2_4
Xpsn_inst_psn_buff_28 psn_inst_psn_buff_28/A psn_inst_psn_buff_25/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_348 VGND VPWR sky130_fd_sc_hd__decap_12
X_4422_ _4421_/Y _4422_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7210_ _7167_/X _7169_/X _7196_/C _5881_/X _7209_/A _7210_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
Xpsn_inst_psn_buff_39 psn_inst_psn_buff_50/X psn_inst_psn_buff_34/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_8_483 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_370 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_510 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_733 VGND VPWR sky130_fd_sc_hd__fill_2
X_7141_ _4255_/X _7106_/X _7119_/B east_double_in[1] _7141_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4353_ _4353_/A _4352_/X _7644_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_565 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_716 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_788 VGND VPWR sky130_fd_sc_hd__decap_4
X_4284_ _4280_/Y _4283_/X _7659_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7072_ _7072_/A _7072_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_59_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_384 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_204 VGND VPWR sky130_fd_sc_hd__decap_8
X_6023_ _6023_/A _6023_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_335 VGND VPWR sky130_fd_sc_hd__fill_1
X_6925_ _6925_/A _6926_/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_2507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_891 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6856_ _6855_/X _6859_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_541 VGND VPWR sky130_fd_sc_hd__decap_8
X_3999_ _6520_/B _6537_/B VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6787_ _6784_/X _6786_/X _6780_/A _6791_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_22_276 VGND VPWR sky130_fd_sc_hd__decap_12
X_5807_ _5807_/A _5806_/X _5807_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5738_ _5096_/B _7156_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_135_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_337 VGND VPWR sky130_fd_sc_hd__decap_6
X_5669_ _5669_/A _5670_/B _5669_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_7408_ _7408_/A _7408_/B _7408_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_2_615 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_370 VGND VPWR sky130_fd_sc_hd__decap_8
X_7339_ _7337_/X _7339_/B _7339_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_150_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_576 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_622 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_527 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_847 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_655 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_198 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_880 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_788 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_3_0_clk clkbuf_5_3_0_clk/A _7526_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_70_41 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_627 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_703 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_681 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_696 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_463 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_132 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_699 VGND VPWR sky130_fd_sc_hd__decap_3
X_4971_ _4949_/X _4970_/Y _4966_/X _4972_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_3922_ _6381_/C _6385_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6710_ _6710_/A _6708_/B _6711_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7690_ _7690_/D _4095_/A _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_850 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_541 VGND VPWR sky130_fd_sc_hd__decap_4
X_6641_ _6640_/X _6642_/B _6641_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_3853_ _6193_/B _6232_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_736 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_596 VGND VPWR sky130_fd_sc_hd__fill_2
X_6572_ _6557_/A _6536_/B _6510_/C _6528_/X _6572_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_118_613 VGND VPWR sky130_fd_sc_hd__decap_12
X_3784_ _7743_/Q _6102_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_9_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_5523_ _5523_/A _5522_/X _5523_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5454_ _5453_/Y _5405_/X _5456_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_145_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_690 VGND VPWR sky130_fd_sc_hd__decap_12
X_4405_ _4405_/A conf_vcb[76] _4405_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5385_ _5350_/A _5350_/B _5247_/C _5343_/A _5385_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_7124_ _7127_/A _7124_/B _7124_/C _7124_/D _7124_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_99_541 VGND VPWR sky130_fd_sc_hd__decap_8
X_4336_ _5221_/B _4336_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_113_362 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_747 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_48 VGND VPWR sky130_fd_sc_hd__decap_12
X_4267_ _4267_/A _4266_/X _4267_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7055_ _7054_/X _7072_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6006_ _6001_/A _6001_/B _5988_/C _7260_/D _6006_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_67_460 VGND VPWR sky130_fd_sc_hd__decap_8
X_4198_ _6981_/A _4198_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_55_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_803 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_290 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_463 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_655 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_485 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_625 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6908_ _6706_/A _6908_/B _6909_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_70_658 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_23 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6839_ _6839_/A _6839_/B _6839_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XPHY_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_410 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_635 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_627 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_703 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_478 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_825 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_836 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_622 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_147_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_229 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_240 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_126 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_608 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5170_ _5175_/A _5175_/B _5170_/C _5253_/B VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_111_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_844 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_321 VGND VPWR sky130_fd_sc_hd__decap_12
X_4121_ _7686_/Q _4122_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4052_ _4052_/A conf_hcb[36] _4055_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_110_376 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_611 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_666 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_7742_ _7742_/D _6102_/B _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_24_349 VGND VPWR sky130_fd_sc_hd__decap_3
X_4954_ _4954_/A _6103_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_51_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_3905_ _6330_/A _3905_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7673_ _4202_/Y _6981_/A _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4885_ _4872_/A conf_sb[36] _4885_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_60_691 VGND VPWR sky130_fd_sc_hd__decap_8
X_3836_ _3836_/A _3836_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6624_ _4014_/X _6589_/X _6602_/B _6497_/D _6624_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_20_555 VGND VPWR sky130_fd_sc_hd__decap_12
X_6555_ _6555_/A _6555_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_118_410 VGND VPWR sky130_fd_sc_hd__decap_8
X_3767_ _3764_/Y _3767_/B _3767_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_106_616 VGND VPWR sky130_fd_sc_hd__decap_8
X_5506_ _5465_/X _4626_/X _5496_/C _5505_/X _5501_/X _5506_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6486_ _3956_/A _6486_/B _6486_/C _6486_/D _6486_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3698_ _3793_/A _3699_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5437_ _5432_/X _5434_/Y _5435_/X _5436_/Y _5437_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_99_360 VGND VPWR sky130_fd_sc_hd__decap_6
X_5368_ _5368_/A _5368_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_114_693 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_833 VGND VPWR sky130_fd_sc_hd__decap_12
X_7107_ _7104_/X _7106_/X _7100_/A _7110_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4319_ _4304_/X _5119_/A _4318_/X _4320_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_59_224 VGND VPWR sky130_fd_sc_hd__decap_3
X_5299_ _4537_/Y _4544_/A _5299_/C _5223_/X _5299_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_101_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_577 VGND VPWR sky130_fd_sc_hd__decap_3
X_7038_ _7045_/C _7037_/X _7038_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_87_599 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_791 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_68 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_422 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_708 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_522 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_500 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_240 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_284 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_468 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_514 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_547 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_772 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_466 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_831 VGND VPWR sky130_fd_sc_hd__fill_1
X_4670_ _5658_/A _5607_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_30_853 VGND VPWR sky130_fd_sc_hd__decap_4
X_6340_ _6340_/A1 _6337_/Y _6339_/Y _6340_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_143_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_6271_ _6270_/X _6272_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_6_592 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_276 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_107 VGND VPWR sky130_fd_sc_hd__decap_8
X_5222_ _7648_/Q _5220_/Y _5221_/X _5222_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_5153_ _5154_/A _5151_/Y _5152_/Y _5153_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_111_663 VGND VPWR sky130_fd_sc_hd__decap_8
X_4104_ _4104_/A _4104_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5084_ _3693_/A west_double_in[1] _3687_/Y _5084_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_57_739 VGND VPWR sky130_fd_sc_hd__fill_1
X_4035_ _7700_/Q _4035_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_112_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_260 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_293 VGND VPWR sky130_fd_sc_hd__fill_1
X_5986_ _5994_/B _5988_/C VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_119 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VPWR sky130_fd_sc_hd__decap_3
X_7725_ _3889_/Y _7725_/Q _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4937_ _4937_/A _4937_/B _4937_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7656_ _7656_/D _5075_/B _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4868_ _4819_/A _4868_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_6607_ _4012_/X _7703_/Q _6602_/Y _6606_/Y _6607_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_3819_ _3805_/X _6124_/A _3794_/X _3819_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_107_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_4799_ _4792_/X _5899_/A _4780_/X _4799_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7587_ _4668_/Y _4664_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_593 VGND VPWR sky130_fd_sc_hd__decap_12
X_6538_ _6538_/A _6555_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_413 VGND VPWR sky130_fd_sc_hd__fill_1
X_6469_ _3956_/X _3962_/X _6481_/C _6601_/D _6501_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_134_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_12 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_449 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_674 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_652 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_706 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_151 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_783 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_753 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_720 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_271 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_636 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_274 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_330 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_273 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_262 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_573 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_138 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_94 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_471 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_293 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_794 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_775 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_444 VGND VPWR sky130_fd_sc_hd__decap_12
X_5840_ _5839_/X _5889_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5771_ _5770_/X _5782_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_628 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_7510_ _5049_/Y _5047_/A _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_14_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_4722_ _4722_/A _4721_/X _7577_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7441_ _7441_/HI east_clb_input[17] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_324 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_147_379 VGND VPWR sky130_fd_sc_hd__decap_12
X_4653_ _4103_/A _4735_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7372_ _7407_/A _7407_/B _7370_/A _7370_/B _7372_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4584_ _4579_/Y _4584_/B _7602_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_143_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_530 VGND VPWR sky130_fd_sc_hd__decap_8
X_6323_ _6320_/X _6322_/X _3887_/Y _6324_/B VGND VPWR sky130_fd_sc_hd__or3_4
X_6254_ _3858_/Y _6254_/B _6312_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_107_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5205_ _5193_/X _5198_/X _5201_/Y _5204_/Y _5205_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_131_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_6185_ _6248_/A _6185_/B _6185_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_97_661 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_845 VGND VPWR sky130_fd_sc_hd__decap_8
X_5136_ _5123_/A _7641_/Q _5055_/A _5135_/X _4363_/Y _5136_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_123_48 VGND VPWR sky130_fd_sc_hd__decap_12
X_5067_ _4276_/Y _5067_/B _5056_/A _5067_/D _5067_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_84_355 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_344 VGND VPWR sky130_fd_sc_hd__decap_8
X_4018_ _7703_/Q _4018_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_26_901 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_5969_ _5968_/Y _5967_/X east_clb_input[1] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_80_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_105 VGND VPWR sky130_fd_sc_hd__decap_12
X_7708_ _3993_/Y _6547_/B _7703_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_138_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_7639_ _4379_/Y _4377_/A _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_582 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_733 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_596 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_276 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_683 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_525 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_344 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_558 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_506 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_422 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_358 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_775 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_263 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_313 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_500 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_672 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_834 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_823 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_514 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_314 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_196 VGND VPWR sky130_fd_sc_hd__decap_3
X_6941_ _6938_/A _6941_/B _6941_/C _6674_/D _6941_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_19_293 VGND VPWR sky130_fd_sc_hd__decap_12
X_6872_ _6862_/B _6872_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5823_ _5823_/A _7754_/Q _3738_/A _5100_/D _5823_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_34_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_285 VGND VPWR sky130_fd_sc_hd__decap_12
X_5754_ _7575_/Q _5754_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_148_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_132 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_121 VGND VPWR sky130_fd_sc_hd__fill_1
X_4705_ _4701_/Y _4705_/B _4705_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5685_ _5684_/X _5685_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_7424_ _7424_/HI clb_output_south[6] VGND VPWR sky130_fd_sc_hd__conb_1
X_4636_ _5495_/B _4636_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_116_541 VGND VPWR sky130_fd_sc_hd__decap_3
X_7355_ _7364_/A _4492_/A _7356_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_150_308 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_861 VGND VPWR sky130_fd_sc_hd__decap_12
X_6306_ _6306_/A _6305_/X _6306_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_104_703 VGND VPWR sky130_fd_sc_hd__decap_4
X_4567_ _4563_/Y _4567_/B _7605_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_596 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_725 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_213 VGND VPWR sky130_fd_sc_hd__decap_3
X_7286_ _7286_/A _7226_/X _7286_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4498_ _4090_/A _4499_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6237_ _6237_/A _6210_/Y _6237_/C _6239_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_77_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_801 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_780 VGND VPWR sky130_fd_sc_hd__decap_8
X_6168_ _6166_/X _6167_/Y _6168_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_69_160 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_653 VGND VPWR sky130_fd_sc_hd__fill_1
X_5119_ _5119_/A _7650_/Q _4328_/A _5119_/D _5119_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_6099_ _6095_/X _3780_/Y _6089_/X _6096_/X _6098_/X _6401_/A VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_17_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_764 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_636 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_614 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_668 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_533 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_706 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_300 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_377 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_314 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_580 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_528 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_539 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_656 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_870 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_90 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_291 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_280 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_29 psn_inst_psn_buff_35/X psn_inst_psn_buff_26/A VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_18 _5939_/A _7388_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5470_ _5509_/C _5470_/B _5470_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_145_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_124 VGND VPWR sky130_fd_sc_hd__decap_8
X_4421_ _7225_/C _4421_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_69_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_382 VGND VPWR sky130_fd_sc_hd__decap_4
X_7140_ _7101_/A _4271_/X _7131_/C _7132_/B _7140_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4352_ _4350_/X _4351_/Y _4341_/X _4352_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_152_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_4283_ _4281_/X _4282_/Y _4272_/X _4283_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7071_ _7066_/X _7068_/Y _7069_/X _7070_/X _7071_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_4_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_728 VGND VPWR sky130_fd_sc_hd__decap_4
X_6022_ _6022_/A _6022_/B _6022_/C _6022_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_98_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_439 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_483 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_623 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_859 VGND VPWR sky130_fd_sc_hd__fill_1
X_6924_ _6922_/B _6924_/B _6925_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_82_678 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_369 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_689 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6855_ _6855_/A _6855_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_520 VGND VPWR sky130_fd_sc_hd__fill_2
X_3998_ _3981_/A conf_hcb[45] _3998_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6786_ _6785_/X _6786_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5806_ _5806_/A _5806_/B _5806_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5737_ _7757_/Q _6184_/A _5737_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_22_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_597 VGND VPWR sky130_fd_sc_hd__decap_8
X_7407_ _7407_/A _7407_/B vertical_global[1] _7365_/A _7408_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_5668_ _5667_/Y _5666_/X _5669_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_2_605 VGND VPWR sky130_fd_sc_hd__fill_1
X_4619_ _5490_/A _5503_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5599_ _5544_/X _5547_/X _5598_/X _5600_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_116_382 VGND VPWR sky130_fd_sc_hd__decap_12
X_7338_ _7306_/A _7306_/B _7306_/C _5177_/X _7308_/X _7339_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_2_627 VGND VPWR sky130_fd_sc_hd__decap_12
X_7269_ _4422_/X _7232_/X _7228_/X _7269_/D _7269_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_132_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_472 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_859 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_678 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_667 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_564 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_124 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_113 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_466 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_809 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_330 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_748 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_693 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_100 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_583 VGND VPWR sky130_fd_sc_hd__decap_8
X_4970_ _4970_/A _4970_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3921_ _3863_/A _3921_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_44_380 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_391 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_205 VGND VPWR sky130_fd_sc_hd__decap_12
X_3852_ _3852_/A _6193_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6640_ _6640_/A _6640_/B _6640_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_20_715 VGND VPWR sky130_fd_sc_hd__decap_12
X_6571_ _6571_/A _6571_/B _6571_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_118_625 VGND VPWR sky130_fd_sc_hd__decap_12
X_3783_ _3787_/A conf_hcb[82] _3783_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5522_ _5522_/A _5522_/B _5522_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_118_658 VGND VPWR sky130_fd_sc_hd__decap_12
X_5453_ _5171_/X _5408_/X _5452_/X _5453_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4404_ _4404_/A _4404_/B _4404_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5384_ _5382_/X _5383_/X _5386_/A VGND VPWR sky130_fd_sc_hd__nand2_4
X_7123_ _7123_/A1 _7120_/Y _7122_/Y _7124_/D VGND VPWR sky130_fd_sc_hd__a21oi_4
X_4335_ _4344_/A conf_vcb[90] _4335_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_141_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_586 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_396 VGND VPWR sky130_fd_sc_hd__decap_8
X_4266_ _4252_/X _7101_/A _4241_/X _4266_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_87_759 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_247 VGND VPWR sky130_fd_sc_hd__decap_12
X_7054_ _7054_/A _7054_/B _7054_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6005_ _5981_/A _4831_/A _5975_/A _4821_/A _6005_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4197_ _4189_/X conf_hcb[12] _4202_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_28_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_19_0_clk clkbuf_4_9_0_clk/X _7688_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_82_431 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_667 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_818 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_637 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_615 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_306 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6907_ _6906_/Y _6908_/B _6909_/B VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6838_ _4123_/X _6837_/X _6811_/C _6791_/A _6839_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XPHY_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_383 VGND VPWR sky130_fd_sc_hd__decap_12
X_6769_ _6769_/A _6769_/B _6510_/C _6769_/D _6770_/B VGND VPWR sky130_fd_sc_hd__or4_4
XPHY_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_658 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_466 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_903 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_680 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_691 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_374 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_20 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_483 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_848 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_637 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_114 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_147 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_96 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_230 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_455 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_425 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_737 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_311 VGND VPWR sky130_fd_sc_hd__fill_1
X_4120_ _4110_/A conf_hcb[25] _4126_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4051_ _4046_/Y _4051_/B _4051_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_111_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_707 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_910 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_442 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_431 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_881 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_294 VGND VPWR sky130_fd_sc_hd__decap_8
X_7741_ _3796_/Y _7741_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_840 VGND VPWR sky130_fd_sc_hd__decap_12
X_4953_ _4960_/A conf_sb[22] _4953_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3904_ _3898_/A conf_hcb[61] _3907_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7672_ _7672_/D _6990_/A _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_51_147 VGND VPWR sky130_fd_sc_hd__decap_12
X_6623_ _6614_/A _6623_/B _6619_/C _6620_/B _6623_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4884_ _4884_/A _4884_/B _7546_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_3835_ _3835_/A _3836_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_567 VGND VPWR sky130_fd_sc_hd__decap_12
X_6554_ _6549_/X _6551_/Y _6552_/X _6553_/X _6554_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3766_ _3756_/X _5144_/A _3747_/X _3767_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_146_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_241 VGND VPWR sky130_fd_sc_hd__decap_3
X_6485_ _3966_/Y _6480_/D _6452_/X _6481_/B _6485_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5505_ _5104_/X _5505_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3697_ _7761_/Q _5100_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_10_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5436_ _5440_/A _5440_/B _5433_/A south_double_out[1] _5436_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_126_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_119 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_650 VGND VPWR sky130_fd_sc_hd__decap_8
X_5367_ _5363_/X _5364_/Y _5365_/X _5366_/X _5367_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_0_906 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_683 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_845 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_300 VGND VPWR sky130_fd_sc_hd__decap_4
X_7106_ _7132_/B _7106_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4318_ _4272_/A _4318_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5298_ _4549_/Y _4554_/X _5289_/A _4544_/Y _5298_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4249_ _4249_/A _4264_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7037_ _7054_/A _7037_/B _4221_/A _4228_/A _7037_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_59_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_258 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_2_0_clk clkbuf_5_3_0_clk/A _7522_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_101_399 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_612 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_291 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_431 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_840 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_862 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_534 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_400 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_266 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_650 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_631 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_160 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_206 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_634 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_261 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_250 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_689 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_626 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_294 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_272 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_436 VGND VPWR sky130_fd_sc_hd__fill_1
X_6270_ _6270_/A _6270_/B _6270_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_51_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_501 VGND VPWR sky130_fd_sc_hd__fill_1
X_5221_ _4332_/Y _5221_/B _5216_/A _5221_/D _5221_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_123_480 VGND VPWR sky130_fd_sc_hd__decap_8
X_5152_ _4377_/Y _5154_/A east_clb_output[1] _4377_/A _5155_/A _5152_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_110_141 VGND VPWR sky130_fd_sc_hd__decap_12
X_4103_ _4103_/A _4104_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_110_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_537 VGND VPWR sky130_fd_sc_hd__decap_3
X_5083_ _5083_/A _5736_/A _5083_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_38_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_4034_ _4017_/A conf_hcb[39] _4037_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_65_751 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_475 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_272 VGND VPWR sky130_fd_sc_hd__decap_3
X_7724_ _3897_/Y _3893_/A _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5985_ _5980_/A _5994_/B VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_109 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_467 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_798 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_670 VGND VPWR sky130_fd_sc_hd__fill_1
X_4936_ _4926_/X _6050_/A _4906_/X _4937_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XANTENNA_10 clb_output[6] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_506 VGND VPWR sky130_fd_sc_hd__fill_2
X_7655_ _7655_/D _5075_/C _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4867_ _4872_/A conf_sb[40] _4867_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6606_ _6606_/A1 _6603_/Y _6605_/Y _6606_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_119_731 VGND VPWR sky130_fd_sc_hd__fill_1
X_3818_ _7737_/Q _6124_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7586_ _4673_/Y _5658_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6537_ _6520_/A _6537_/B _6538_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4798_ _5916_/A _5899_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_3749_ _3745_/Y _3748_/X _7751_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6468_ _6467_/X _6481_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_108_7 VGND VPWR sky130_fd_sc_hd__fill_1
X_6399_ _6399_/A _6419_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5419_ _5406_/B _5184_/X _5190_/X _5416_/A _5419_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_0_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_24 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_642 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_769 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_507 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_209 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_592 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_810 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_489 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_539 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_230 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_520 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_480 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_9_0_clk clkbuf_3_4_0_clk/X clkbuf_4_9_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_3_585 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_3 VGND VPWR sky130_fd_sc_hd__decap_4
X_5770_ _4741_/A _4745_/Y _5770_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_15_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_681 VGND VPWR sky130_fd_sc_hd__decap_8
X_4721_ _4708_/X _5715_/B _4698_/X _4721_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_148_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_7440_ _7440_/HI east_clb_input[16] VGND VPWR sky130_fd_sc_hd__conb_1
X_4652_ _4651_/X conf_vcb[32] _4658_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_128_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_701 VGND VPWR sky130_fd_sc_hd__fill_1
X_7371_ _7353_/A _7407_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4583_ _4570_/X _5350_/B _4560_/X _4584_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6322_ _6321_/X _6322_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_211 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_6253_ _6270_/A _6263_/B _6253_/C _3870_/Y _6254_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_107_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_139 VGND VPWR sky130_fd_sc_hd__decap_12
X_5204_ _5229_/C _5229_/D _5195_/X _5203_/X _5204_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6184_ _6184_/A _6248_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_236 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_331 VGND VPWR sky130_fd_sc_hd__decap_12
X_5135_ _7642_/Q _5124_/X _5134_/Y _5135_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_69_375 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_364 VGND VPWR sky130_fd_sc_hd__fill_2
X_5066_ _5066_/A _5211_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_57_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_537 VGND VPWR sky130_fd_sc_hd__fill_1
X_4017_ _4017_/A conf_hcb[42] _4022_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_26_913 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_294 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_5968_ _6034_/A _5968_/B _5968_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_12_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_426 VGND VPWR sky130_fd_sc_hd__decap_8
X_7707_ _3997_/Y _6520_/A _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_40_459 VGND VPWR sky130_fd_sc_hd__fill_1
X_4919_ _7538_/Q _4919_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5899_ _5899_/A _4802_/Y _5899_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_154_807 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_509 VGND VPWR sky130_fd_sc_hd__decap_8
X_7638_ _7638_/D _5154_/A _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_5_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_7569_ _4766_/Y _5833_/A _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_134_520 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_756 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_857 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_93 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_220 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_275 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_437 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_325 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_666 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_895 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_512 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_426 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_610 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_312 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_131 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_537 VGND VPWR sky130_fd_sc_hd__decap_12
X_6940_ _6946_/A _6938_/B _6965_/A _6915_/B _6940_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_66_378 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_367 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_849 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_337 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_389 VGND VPWR sky130_fd_sc_hd__decap_8
X_6871_ _6881_/A _6871_/B _6876_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_62_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_5822_ _3738_/A _5815_/X _5816_/X _5820_/X _5821_/X _5822_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_35_776 VGND VPWR sky130_fd_sc_hd__decap_12
X_5753_ _5752_/X _5753_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_22_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_297 VGND VPWR sky130_fd_sc_hd__decap_12
X_4704_ _4681_/X _5716_/A _4698_/X _4705_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_147_144 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_481 VGND VPWR sky130_fd_sc_hd__decap_8
X_5684_ _5681_/X _5684_/B _5684_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_148_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_317 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_306 VGND VPWR sky130_fd_sc_hd__fill_2
X_7423_ _7423_/HI clb_output_south[5] VGND VPWR sky130_fd_sc_hd__conb_1
X_4635_ _5480_/B _5495_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_128_391 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_7354_ _4470_/Y _7353_/X _7414_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4566_ _4543_/X _5375_/A _4560_/X _4567_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_144_873 VGND VPWR sky130_fd_sc_hd__decap_12
X_6305_ _6269_/A _6269_/B _6243_/C _6261_/X _6305_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_116_553 VGND VPWR sky130_fd_sc_hd__decap_12
X_7285_ _7284_/Y _7285_/B _7286_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_89_426 VGND VPWR sky130_fd_sc_hd__fill_1
X_4497_ _7616_/Q _4497_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_134_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_6236_ _6236_/A _6235_/Y _6237_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_103_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_770 VGND VPWR sky130_fd_sc_hd__fill_1
X_6167_ _6131_/C _6131_/D _6156_/Y _6082_/X _6163_/X _6167_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_100_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5118_ _7650_/Q _5114_/X _5115_/X _5116_/X _5117_/X _5118_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6098_ _6098_/A _7744_/Q _6097_/X _6098_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_57_367 VGND VPWR sky130_fd_sc_hd__decap_4
X_5049_ _5049_/A _5049_/B _5049_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_26_710 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_144 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_122 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_103 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_492 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_648 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_575 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_770 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_632 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_142 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_96 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_270 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_292 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_281 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_19 _5065_/Y _5221_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_659 VGND VPWR sky130_fd_sc_hd__decap_12
X_4420_ _4405_/A conf_vcb[73] _4424_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_8_496 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_309 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_724 VGND VPWR sky130_fd_sc_hd__decap_8
X_4351_ _7644_/Q _4351_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_140_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_534 VGND VPWR sky130_fd_sc_hd__decap_12
X_4282_ _5067_/B _4282_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7070_ _7070_/A _7075_/B _7067_/Y _6416_/A _7070_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6021_ _6019_/X _6020_/Y _6022_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_86_418 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_676 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_367 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_315 VGND VPWR sky130_fd_sc_hd__decap_12
X_6923_ _6915_/A _6923_/B _6924_/B VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_2509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6854_ _6854_/A _6881_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_62_381 VGND VPWR sky130_fd_sc_hd__decap_12
X_3997_ _3997_/A _3997_/B _3997_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6785_ _7688_/Q _6785_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5805_ _5805_/A _5805_/B _5805_/C _5760_/B _5806_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_148_431 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5736_ _5736_/A _6184_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_587 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5667_ _5526_/X _5667_/B _5667_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_135_114 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_328 VGND VPWR sky130_fd_sc_hd__decap_8
X_7406_ _7404_/X _7405_/X _7408_/A VGND VPWR sky130_fd_sc_hd__nand2_4
X_4618_ _5460_/C _5490_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5598_ _5598_/A _5598_/B _5598_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_89_212 VGND VPWR sky130_fd_sc_hd__decap_8
X_7337_ _7308_/X _7337_/B _7336_/X _7337_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_2_639 VGND VPWR sky130_fd_sc_hd__fill_2
X_4549_ _7608_/Q _4549_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_116_394 VGND VPWR sky130_fd_sc_hd__decap_3
X_7268_ _4433_/Y _4439_/X _7230_/X _7232_/X _7268_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_89_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_127 VGND VPWR sky130_fd_sc_hd__decap_12
X_6219_ _3836_/A _6228_/D _6229_/C _6219_/D _6219_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_132_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_375 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_610 VGND VPWR sky130_fd_sc_hd__decap_3
X_7199_ _7166_/X _4402_/X _7198_/Y _5865_/X _7195_/X _7199_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_100_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_484 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_197 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_893 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_478 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_136 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_139 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_716 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_672 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_632 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_51 VGND VPWR sky130_fd_sc_hd__decap_8
X_3920_ _3919_/X conf_hcb[58] _3920_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_51_318 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_217 VGND VPWR sky130_fd_sc_hd__decap_12
X_3851_ _6191_/B _3852_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6570_ _6536_/B _6506_/X _6557_/A _6528_/X _6571_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_81_3 VGND VPWR sky130_fd_sc_hd__decap_4
X_3782_ _3782_/A _3781_/X _7744_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5521_ _5478_/X _4636_/X _5247_/C _5470_/B _5522_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_118_637 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_445 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_618 VGND VPWR sky130_fd_sc_hd__decap_12
X_5452_ _5409_/Y _5452_/B _5452_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_132_117 VGND VPWR sky130_fd_sc_hd__decap_8
X_4403_ _4400_/X _4402_/X _4390_/X _4404_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5383_ _5350_/B _5318_/X _5350_/A _5343_/A _5383_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_114_832 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_320 VGND VPWR sky130_fd_sc_hd__decap_12
X_7122_ _7120_/Y _7121_/X _7102_/A _7122_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4334_ _4334_/A _4333_/X _4334_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_141_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_727 VGND VPWR sky130_fd_sc_hd__decap_4
X_7053_ _7074_/A _7078_/B _7053_/C _7079_/B _7053_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4265_ _7662_/Q _7101_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_101_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_215 VGND VPWR sky130_fd_sc_hd__decap_8
X_6004_ _5993_/A _5978_/A _5988_/C _5859_/X _6001_/X _6004_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4196_ _4196_/A _4196_/B _7674_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_131_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6906_ _6789_/X _6864_/A _6905_/X _6906_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XPHY_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6837_ _6174_/Y _6837_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_705 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_6768_ _6766_/X _6768_/B _6768_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_50_395 VGND VPWR sky130_fd_sc_hd__fill_2
X_6699_ _6697_/X _6698_/X _6701_/A VGND VPWR sky130_fd_sc_hd__nand2_4
X_5719_ _5717_/X _5718_/Y _5720_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_40_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_832 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_802 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_719 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_708 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_292 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_65 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_657 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_668 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_679 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_587 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_404 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_226 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_480 VGND VPWR sky130_fd_sc_hd__decap_8
X_4050_ _4040_/X _6658_/B _4031_/X _4051_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_111_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_451 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_454 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_7740_ _3800_/Y _6173_/A _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_91_284 VGND VPWR sky130_fd_sc_hd__fill_1
X_4952_ _4948_/Y _4952_/B _4952_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3903_ _3903_/A _3902_/X _3903_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7671_ _7671_/D _6975_/B _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4883_ _4868_/X _4881_/Y _4882_/X _4884_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_17_392 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_6622_ _6587_/X _4020_/X _6615_/C _6493_/X _6619_/X _6622_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_3834_ _3863_/A _3834_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_535 VGND VPWR sky130_fd_sc_hd__decap_3
X_6553_ _6553_/A _6558_/B _6553_/C _6486_/D _6553_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3765_ _5142_/A _5144_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_20_579 VGND VPWR sky130_fd_sc_hd__fill_1
X_6484_ _3956_/A _6486_/B _6486_/C _6348_/X _6480_/X _6484_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_146_776 VGND VPWR sky130_fd_sc_hd__decap_12
X_3696_ _3702_/A conf_hcb[100] _3701_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5504_ _5497_/X _5500_/Y _5501_/X _5503_/Y _5504_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_10_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_5435_ _5450_/A _5435_/B _5401_/A _5417_/B _5435_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_126_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_150 VGND VPWR sky130_fd_sc_hd__decap_3
X_5366_ _5361_/A _5359_/B _5348_/C _5223_/X _5366_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7105_ _7124_/B _7132_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_101_312 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_524 VGND VPWR sky130_fd_sc_hd__decap_8
X_4317_ _7651_/Q _5119_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5297_ _4538_/X _5266_/X _5299_/C _5296_/X _5291_/X _5297_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_142_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_857 VGND VPWR sky130_fd_sc_hd__decap_12
X_4248_ _4372_/A _4249_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7036_ _7036_/A _7034_/X north_clb_input[2] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_101_367 VGND VPWR sky130_fd_sc_hd__decap_6
X_4179_ _6923_/B _6930_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_27_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_679 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_284 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_318 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_693 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_557 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_546 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_412 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_579 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_415 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_245 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_109 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_71 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_42 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_676 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_218 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_410 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_465 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_830 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_638 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_373 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_660 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_90 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_264 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_404 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_18_0_clk clkbuf_4_9_0_clk/X _7759_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_143_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_297 VGND VPWR sky130_fd_sc_hd__decap_8
X_5220_ _5221_/B _5216_/X _5217_/X _5218_/X _5219_/X _5220_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_44_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_470 VGND VPWR sky130_fd_sc_hd__fill_1
X_5151_ _7538_/Q _4927_/Y east_single_in[3] _5149_/X _5150_/X _5151_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_97_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_354 VGND VPWR sky130_fd_sc_hd__decap_8
X_5082_ north_clb_output[0] _5736_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4102_ _3680_/Y _4103_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4033_ _4027_/Y _4033_/B _4033_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_96_398 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_549 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_571 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_638 VGND VPWR sky130_fd_sc_hd__decap_8
X_7723_ _3903_/Y _6321_/A _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5984_ _5983_/X _5984_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4935_ _7535_/Q _6050_/A VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA_11 east_double_in[0] VGND VPWR sky130_fd_sc_hd__diode_2
X_4866_ _4843_/A _4872_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7654_ _7654_/D _7654_/Q _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_855 VGND VPWR sky130_fd_sc_hd__decap_4
X_6605_ _6603_/Y _6604_/X _6585_/A _6605_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_3817_ _3803_/A conf_hcb[76] _3820_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4797_ _4807_/A conf_vcb[6] _4800_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7585_ _7585_/D _4675_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_888 VGND VPWR sky130_fd_sc_hd__decap_8
X_6536_ _6557_/A _6536_/B _6525_/X _6536_/D _6536_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_119_765 VGND VPWR sky130_fd_sc_hd__fill_2
X_3748_ _3733_/X _3746_/Y _3747_/X _3748_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_20_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_6467_ _6448_/A _3971_/A _6467_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_137_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_286 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_256 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_6398_ _6396_/A _6398_/B _6399_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_106_459 VGND VPWR sky130_fd_sc_hd__decap_8
X_5418_ _5188_/X _5410_/Y _5423_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_133_278 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_481 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_470 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_621 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_822 VGND VPWR sky130_fd_sc_hd__fill_2
X_5349_ _5351_/A _5350_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_0_726 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_387 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_7019_ _6991_/C _7017_/B _7010_/Y _6362_/A _7016_/X _7020_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_56_730 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_410 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_733 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_413 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_276 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_800 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_510 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_286 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_597 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_719 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_560 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_593 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_571 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_243 VGND VPWR sky130_fd_sc_hd__fill_1
X_4720_ _4720_/A _5715_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_148_849 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_1_0_clk clkbuf_5_1_0_clk/A _7529_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_4651_ _4733_/A _4651_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7370_ _7370_/A _7370_/B _7370_/C _7242_/D _7404_/B VGND VPWR sky130_fd_sc_hd__and4_4
X_4582_ _5370_/B _5350_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6321_ _6321_/A _6321_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_201 VGND VPWR sky130_fd_sc_hd__fill_1
X_6252_ _6251_/Y _6252_/B clb_input[6] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_115_245 VGND VPWR sky130_fd_sc_hd__fill_2
X_6183_ _6182_/Y _6185_/B _6183_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_88_129 VGND VPWR sky130_fd_sc_hd__fill_1
X_5203_ _7256_/D _5203_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_248 VGND VPWR sky130_fd_sc_hd__decap_8
X_5134_ _5131_/X _5124_/B _5133_/X _5134_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_97_685 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_387 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_335 VGND VPWR sky130_fd_sc_hd__fill_1
X_5065_ clb_output[3] _5065_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4016_ _4016_/A _4015_/X _7704_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_84_379 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_593 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_733 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5967_ _5967_/A _5968_/B _5967_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_52_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_265 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_479 VGND VPWR sky130_fd_sc_hd__decap_8
X_7706_ _7706_/D _6520_/B _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4918_ _4889_/X conf_sb[29] _4921_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_12_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_315 VGND VPWR sky130_fd_sc_hd__decap_12
X_7637_ _7637_/D _7637_/Q _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5898_ _5898_/A _5898_/B _5968_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_138_359 VGND VPWR sky130_fd_sc_hd__decap_8
X_4849_ _4844_/A conf_sb[44] _4849_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_154_819 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_818 VGND VPWR sky130_fd_sc_hd__decap_12
X_7568_ _4770_/Y _5844_/A _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7499_ clb_output[4] clb_output_south[0] VGND VPWR sky130_fd_sc_hd__buf_2
X_6519_ _6519_/A _6519_/B clb_input[2] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_106_223 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_768 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_259 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_379 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_593 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_390 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_468 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_630 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_449 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_287 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_652 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_678 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_841 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_863 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_565 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_705 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_405 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_438 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_259 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_622 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_143 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_711 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_733 VGND VPWR sky130_fd_sc_hd__fill_2
X_6870_ _6889_/A _4142_/X _6889_/C _6664_/D _6870_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5821_ _5816_/A _5744_/A _3738_/Y _5821_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_35_788 VGND VPWR sky130_fd_sc_hd__decap_4
X_5752_ _4741_/Y _4745_/Y _5752_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4703_ _5707_/A _5716_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5683_ _5715_/A _7577_/Q _5684_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_8_93 VGND VPWR sky130_fd_sc_hd__decap_12
X_7422_ _7422_/HI clb_output_south[4] VGND VPWR sky130_fd_sc_hd__conb_1
X_4634_ _7592_/Q _5480_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_7353_ _7353_/A _7353_/B _7353_/C _7353_/D _7353_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4565_ _5361_/A _5375_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6304_ _6304_/A _6303_/X _6306_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_116_565 VGND VPWR sky130_fd_sc_hd__decap_12
X_7284_ _7284_/A _7235_/X _7284_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4496_ _4479_/X conf_vcb[59] _4496_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6235_ _6196_/X _6198_/X _6226_/Y _6082_/X _6232_/X _6235_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_134_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_6166_ _6160_/X _6162_/Y _6163_/X _6165_/Y _6166_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_85_611 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_5117_ _4328_/A north_double_in[2] _4322_/Y _5117_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_69_184 VGND VPWR sky130_fd_sc_hd__decap_8
X_6097_ _6097_/A clb_output[0] _6097_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_84_154 VGND VPWR sky130_fd_sc_hd__decap_4
X_5048_ _4911_/A _6055_/A _5035_/X _5049_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_81_850 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_530 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_202 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_8_0_clk clkbuf_3_4_0_clk/X clkbuf_4_8_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_6999_ _6807_/A1 _6996_/Y _6998_/Y _6999_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_41_736 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_769 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_167 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_115 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_381 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_502 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_587 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_865 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_876 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_803 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_397 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_327 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_766 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_725 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_260 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_293 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_282 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_271 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_318 VGND VPWR sky130_fd_sc_hd__decap_8
X_4350_ _4281_/A _4350_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_546 VGND VPWR sky130_fd_sc_hd__decap_3
X_4281_ _4281_/A _4281_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_140_354 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_579 VGND VPWR sky130_fd_sc_hd__decap_8
X_6020_ _5988_/A _5988_/B _5988_/C _5881_/X _6019_/A _6020_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_67_611 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_327 VGND VPWR sky130_fd_sc_hd__decap_8
X_6922_ _6922_/A _6922_/B _6922_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_54_349 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_541 VGND VPWR sky130_fd_sc_hd__decap_8
X_6853_ _6883_/A _6883_/B _6854_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_62_393 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_758 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_596 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_511 VGND VPWR sky130_fd_sc_hd__decap_8
X_5804_ _5802_/X _5803_/X _5806_/A VGND VPWR sky130_fd_sc_hd__nand2_4
X_3996_ _3982_/X _6552_/A _3973_/X _3997_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6784_ _6821_/C _6784_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_443 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_410 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5735_ _5734_/Y _5733_/X east_clb_input[4] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_129_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_307 VGND VPWR sky130_fd_sc_hd__decap_12
X_5666_ _5666_/A _5667_/B _5666_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_7405_ _7407_/B _6023_/X _7407_/A _7365_/A _7405_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4617_ _4612_/A conf_vcb[38] _4621_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5597_ _5594_/Y _5596_/X _5598_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_145_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_800 VGND VPWR sky130_fd_sc_hd__decap_12
X_7336_ _7336_/A _7336_/B _7336_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4548_ _4548_/A conf_vcb[51] _4551_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_145_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_7267_ _7230_/X _4429_/X _7241_/X _5871_/X _7264_/X _7267_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4479_ _4425_/A _4479_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_1_139 VGND VPWR sky130_fd_sc_hd__decap_12
X_6218_ _3836_/Y _6218_/B _6218_/C _6193_/B _6218_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_131_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_343 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_408 VGND VPWR sky130_fd_sc_hd__decap_8
X_7198_ _7182_/X _7198_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_58_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_622 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_590 VGND VPWR sky130_fd_sc_hd__decap_8
X_6149_ _3806_/X _6158_/D _6133_/X _6219_/D _6149_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_58_677 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_666 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_132 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_636 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_327 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_552 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_574 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_467 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_398 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_85 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_3850_ _3846_/A conf_hcb[70] _3856_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_32_555 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_229 VGND VPWR sky130_fd_sc_hd__decap_12
X_3781_ _3779_/X _3780_/Y _3770_/X _3781_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_60_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_588 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5520_ _5518_/X _5519_/X _5522_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_145_457 VGND VPWR sky130_fd_sc_hd__decap_6
X_5451_ _5449_/Y _5450_/X _5452_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_4402_ _4401_/Y _4402_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5382_ _5382_/A _5382_/B _5382_/C _5382_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_114_844 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_332 VGND VPWR sky130_fd_sc_hd__decap_4
X_7121_ _7661_/Q _6138_/A _6139_/Y _7116_/X _7121_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_4333_ _4327_/X _4332_/Y _4318_/X _4333_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_140_151 VGND VPWR sky130_fd_sc_hd__fill_2
X_4264_ _4264_/A conf_hcb[1] _4267_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_86_205 VGND VPWR sky130_fd_sc_hd__decap_8
X_7052_ _7054_/A _7074_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_184 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_599 VGND VPWR sky130_fd_sc_hd__decap_8
X_6003_ _5999_/X _6000_/X _6001_/X _6002_/Y _6003_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_39_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_290 VGND VPWR sky130_fd_sc_hd__decap_12
X_4195_ _4191_/X _7017_/A _4182_/X _4196_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_28_839 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_338 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_455 VGND VPWR sky130_fd_sc_hd__decap_3
X_6905_ _6905_/A _6905_/B _6905_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_36_872 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_533 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_842 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6836_ _4095_/A _6795_/Y _6836_/C _6839_/A VGND VPWR sky130_fd_sc_hd__or3_4
XPHY_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6767_ _6769_/B _6506_/X _6769_/A _6769_/D _6768_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XPHY_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_717 VGND VPWR sky130_fd_sc_hd__decap_12
X_3979_ _3979_/A _3978_/X _7710_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_137_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_5718_ _5681_/A _5681_/B _5709_/Y _5511_/X _5715_/X _5718_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_148_273 VGND VPWR sky130_fd_sc_hd__fill_2
X_6698_ _6700_/B _6506_/X _6700_/A _6655_/A _6698_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5649_ _5611_/X _4683_/X _5622_/X _5505_/X _5646_/X _5649_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_3_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_844 VGND VPWR sky130_fd_sc_hd__decap_8
X_7319_ _4449_/A _7317_/B _7343_/A _4465_/X _7319_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_120_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_459 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_750 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_806 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_783 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_772 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_463 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_282 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_349 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_127 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_94 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_842 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_396 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_660 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_558 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_368 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_764 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_606 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_797 VGND VPWR sky130_fd_sc_hd__decap_12
X_4951_ _4949_/X _4950_/Y _4940_/X _4952_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_3902_ _3892_/X _3901_/X _3883_/X _3902_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4882_ _4809_/A _4882_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7670_ _7670_/D _7086_/A _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_44_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_6621_ _6616_/X _6618_/Y _6619_/X _6620_/Y _6621_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3833_ _3846_/A conf_hcb[73] _3833_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_6552_ _6552_/A _6557_/B _6525_/A _6552_/D _6552_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3764_ _3760_/A conf_hcb[86] _3764_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_145_210 VGND VPWR sky130_fd_sc_hd__fill_1
X_6483_ _6470_/A _6486_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_3695_ _3692_/Y _3695_/B _7762_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5503_ _5503_/A _5503_/B _5491_/C _5791_/D _5503_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_146_788 VGND VPWR sky130_fd_sc_hd__decap_12
X_5434_ _5401_/A _5417_/B _5433_/Y south_double_out[0] _5430_/X _5434_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
X_7104_ _7131_/C _7104_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5365_ _5342_/A _5370_/B _5359_/A _5362_/B _5365_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_102_825 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_396 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_385 VGND VPWR sky130_fd_sc_hd__fill_2
X_4316_ _4321_/A conf_vcb[94] _4320_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5296_ _5859_/A _5296_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_102_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_335 VGND VPWR sky130_fd_sc_hd__decap_8
X_4247_ _4244_/Y _4246_/X _4247_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_87_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_558 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_750 VGND VPWR sky130_fd_sc_hd__decap_12
X_7035_ _7159_/A _6976_/X _7036_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_19_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_4178_ _4161_/A conf_hcb[15] _4178_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_19_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_797 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_680 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_628 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6819_ _6812_/C _6819_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_886 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_683 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_385 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_424 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_569 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_232 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_457 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_32 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_794 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_680 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_64 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_864 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_80 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_650 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_91 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_694 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_221 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_287 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_584 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_622 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_611 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_823 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5150_ _4927_/Y north_single_in[2] _4919_/Y _5150_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_110_110 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_4101_ _4110_/A conf_hcb[28] _4101_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_69_569 VGND VPWR sky130_fd_sc_hd__fill_2
X_5081_ _5083_/A _5096_/B _5081_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4032_ _4011_/X _6623_/B _4031_/X _4033_/B VGND VPWR sky130_fd_sc_hd__a21o_4
Xclkbuf_1_1_0_clk clkbuf_0_clk/X clkbuf_2_3_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_65_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_444 VGND VPWR sky130_fd_sc_hd__fill_1
X_5983_ _5982_/X _5983_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_64_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_105 VGND VPWR sky130_fd_sc_hd__decap_12
X_7722_ _7722_/D _6330_/A _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_80_767 VGND VPWR sky130_fd_sc_hd__decap_12
X_4934_ _4934_/A conf_sb[26] _4937_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4865_ _4865_/A _4864_/X _7550_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XANTENNA_12 east_double_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
X_7653_ _7653_/D _4309_/A _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_480 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_300 VGND VPWR sky130_fd_sc_hd__decap_12
X_6604_ _6582_/B _6472_/X _6473_/X _6599_/X _6604_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_119_711 VGND VPWR sky130_fd_sc_hd__decap_3
X_3816_ _3811_/Y _3816_/B _3816_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4796_ _4796_/A _4796_/B _4796_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7584_ _4685_/Y _5635_/B _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6535_ _6520_/A _6557_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_232 VGND VPWR sky130_fd_sc_hd__decap_3
X_3747_ _3699_/A _3747_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_377 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_552 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_6466_ _6480_/C _3972_/X _6453_/X _6455_/X _6466_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_118_276 VGND VPWR sky130_fd_sc_hd__decap_3
X_6397_ _6438_/A _6397_/B _6389_/A _6428_/B _6397_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5417_ _5440_/A _5417_/B _5433_/A north_double_out[3] _5417_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_88_834 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_300 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_738 VGND VPWR sky130_fd_sc_hd__decap_6
X_5348_ _5348_/A _5348_/B _5348_/C _5277_/X _5382_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_153_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_633 VGND VPWR sky130_fd_sc_hd__decap_8
X_7018_ _7014_/X _7015_/Y _7016_/X _7017_/Y _7018_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5279_ _7608_/Q _5279_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_47_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_699 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_399 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_550 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_775 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_499 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_425 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_745 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_244 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_458 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_469 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_480 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_544 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_311 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_300 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_506 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_496 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_753 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_775 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_767 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_745 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_469 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4650_ _4372_/A _4733_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_642 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_664 VGND VPWR sky130_fd_sc_hd__decap_8
X_6320_ _6355_/C _6320_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4581_ _5333_/B _5370_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6251_ _6251_/A _6250_/B _6251_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_89_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_599 VGND VPWR sky130_fd_sc_hd__decap_8
X_6182_ _6123_/X _6126_/X _6181_/X _6182_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_103_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_620 VGND VPWR sky130_fd_sc_hd__decap_12
X_5202_ south_single_in[1] _7256_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_97_642 VGND VPWR sky130_fd_sc_hd__decap_12
X_5133_ _7530_/Q _5132_/Y _5133_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_506 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_697 VGND VPWR sky130_fd_sc_hd__decap_3
X_5064_ _5067_/B _5056_/X _5059_/X _5062_/X _5063_/X _5064_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4015_ _4011_/X _4014_/X _4002_/X _4015_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_38_775 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_520 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_907 VGND VPWR sky130_fd_sc_hd__decap_8
X_5966_ _5966_/A _5964_/X _5967_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_139_806 VGND VPWR sky130_fd_sc_hd__decap_12
X_7705_ _4008_/Y _4006_/A _7703_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5897_ _5916_/A _4802_/A _5901_/A _5935_/B _5898_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_4917_ _4959_/A _4917_/B _4917_/C _7539_/D VGND VPWR sky130_fd_sc_hd__nor3_4
XFILLER_52_288 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_439 VGND VPWR sky130_fd_sc_hd__decap_8
X_7636_ _7636_/D _4389_/A _7629_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4848_ _4848_/A _4848_/B _4848_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_327 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_675 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_541 VGND VPWR sky130_fd_sc_hd__decap_8
X_4779_ rst _4809_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7567_ _4776_/Y _5826_/B _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7498_ clb_input_west[7] clb_input[31] VGND VPWR sky130_fd_sc_hd__buf_2
X_6518_ _6642_/A _6517_/B _6519_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6449_ _6456_/C _6448_/X _6517_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_122_739 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_642 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_557 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_837 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_904 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_73 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_701 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_5_17_0_clk clkbuf_4_8_0_clk/X _7692_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_44_745 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_767 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_642 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_772 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_100 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_155 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_884 VGND VPWR sky130_fd_sc_hd__fill_1
X_5820_ _5817_/X _5818_/X _7754_/Q _5819_/X _5820_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5751_ _4724_/Y _5751_/B _5812_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4702_ _5672_/C _5707_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7421_ _7421_/HI clb_output_south[3] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_113 VGND VPWR sky130_fd_sc_hd__decap_8
X_5682_ _5716_/C _5681_/X _5731_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4633_ _4645_/A conf_vcb[35] _4638_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7352_ _7351_/Y _7350_/X clb_input[13] VGND VPWR sky130_fd_sc_hd__nor2_4
X_4564_ _5331_/C _5361_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6303_ _6269_/B _6175_/X _6269_/A _6261_/X _6303_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_116_533 VGND VPWR sky130_fd_sc_hd__decap_8
X_7283_ _7283_/A _7235_/X _7285_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_144_886 VGND VPWR sky130_fd_sc_hd__decap_12
X_6234_ _6230_/X _6231_/Y _6232_/X _6233_/Y _6236_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_116_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_205 VGND VPWR sky130_fd_sc_hd__decap_8
X_4495_ _4495_/A _4494_/X _4495_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_103_249 VGND VPWR sky130_fd_sc_hd__fill_1
X_6165_ _6129_/A _6131_/D _6122_/A _6360_/D _6165_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_69_152 VGND VPWR sky130_fd_sc_hd__decap_8
X_5116_ _5115_/A _5137_/B _5116_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6096_ _6089_/B north_clb_output[0] _6096_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_58_837 VGND VPWR sky130_fd_sc_hd__decap_8
X_5047_ _5047_/A _6055_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_27_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_561 VGND VPWR sky130_fd_sc_hd__decap_3
X_6998_ _6996_/Y _6997_/X _6977_/X _6998_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_53_553 VGND VPWR sky130_fd_sc_hd__decap_12
X_5949_ _4785_/X _5948_/D _5900_/X _7269_/D _5949_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_13_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_748 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_247 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_269 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_647 VGND VPWR sky130_fd_sc_hd__decap_12
X_7619_ _7619_/D _4482_/A _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_153_127 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_179 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_544 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_514 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_750 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_855 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_888 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_794 VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_5_0_0_clk clkbuf_5_1_0_clk/A _7514_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_63_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_136 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_339 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_745 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_542 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_93 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_110 _5211_/D psn_inst_psn_buff_110/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_261 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_250 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_294 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_283 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_781 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_396 VGND VPWR sky130_fd_sc_hd__decap_12
X_4280_ _4285_/A conf_vcb[102] _4280_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_141_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_569 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_472 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_615 VGND VPWR sky130_fd_sc_hd__decap_8
X_6921_ _6921_/A _6921_/B _4157_/Y _6922_/B VGND VPWR sky130_fd_sc_hd__or3_4
X_6852_ _6859_/C _6851_/X _6911_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_23_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_670 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_748 VGND VPWR sky130_fd_sc_hd__fill_1
X_5803_ _5805_/B _5659_/X _5805_/A _5760_/B _5803_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3995_ _6520_/A _6552_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6783_ _4106_/A _6821_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_5734_ _5813_/A _5673_/X _5734_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_148_455 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_5665_ _5544_/X _5619_/X _5664_/X _5666_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_7404_ _7621_/Q _7404_/B _7404_/C _7404_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_4616_ _4612_/Y _4615_/X _4616_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_117_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_330 VGND VPWR sky130_fd_sc_hd__decap_6
X_7335_ _7306_/A _7306_/B _7326_/Y _5076_/Y _7332_/X _7336_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5596_ _5552_/X _4666_/X _5805_/C _5546_/A _5596_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_145_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_812 VGND VPWR sky130_fd_sc_hd__decap_12
X_4547_ _4547_/A _4547_/B _7609_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_143_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_182 VGND VPWR sky130_fd_sc_hd__fill_1
X_7266_ _7261_/X _7263_/Y _7264_/X _7265_/Y _7266_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4478_ _4478_/A _4478_/B _7620_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6217_ _3836_/A _6228_/D _6229_/C _6146_/X _6191_/X _6217_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_7197_ _7193_/X _7194_/Y _7195_/X _7196_/X _7197_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_89_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_6148_ _6148_/A _3812_/A _6179_/A _3823_/X _6148_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_57_144 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_764 VGND VPWR sky130_fd_sc_hd__decap_4
X_6079_ _7543_/Q _5313_/X _4892_/Y _6079_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_45_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_380 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_158 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_770 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_105 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_447 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_650 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_479 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_539 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_528 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_591 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_445 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_810 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_361 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_545 VGND VPWR sky130_fd_sc_hd__fill_1
X_3780_ _7744_/Q _3780_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_60_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_251 VGND VPWR sky130_fd_sc_hd__decap_12
X_5450_ _5450_/A _5450_/B _5247_/C _5405_/B _5450_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4401_ _7189_/B _4401_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_67_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_501 VGND VPWR sky130_fd_sc_hd__decap_8
X_5381_ _5379_/X _5380_/Y _5382_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_114_856 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_823 VGND VPWR sky130_fd_sc_hd__fill_1
X_7120_ _7120_/A _7120_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4332_ _7648_/Q _4332_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_51 VGND VPWR sky130_fd_sc_hd__decap_8
X_4263_ _4263_/A _4263_/B _4263_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7051_ _7075_/A _7056_/B _7079_/C _6795_/D _7086_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_6002_ _5975_/A _4821_/A _6008_/A _7192_/D _6002_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
Xclkbuf_4_7_0_clk clkbuf_4_7_0_clk/A clkbuf_4_7_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_83_902 VGND VPWR sky130_fd_sc_hd__fill_2
X_4194_ _4194_/A _7017_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_67_475 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_423 VGND VPWR sky130_fd_sc_hd__decap_8
X_6904_ _6904_/A _6904_/B _6905_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_70_607 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_350 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_884 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6835_ _6835_/A _6834_/Y _6836_/C VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_180 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_545 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_394 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_320 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_720 VGND VPWR sky130_fd_sc_hd__decap_12
X_3978_ _3953_/X _3977_/Y _3973_/X _3978_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6766_ _7695_/Q _6726_/Y _6765_/X _6766_/X VGND VPWR sky130_fd_sc_hd__or3_4
XPHY_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_589 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_887 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_606 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_5717_ _5713_/X _5714_/Y _5715_/X _5716_/Y _5717_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6697_ _7700_/Q _6658_/Y _6696_/X _6697_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_40_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5648_ _5643_/X _5645_/Y _5646_/X _5647_/Y _5648_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_117_672 VGND VPWR sky130_fd_sc_hd__decap_8
X_5579_ _5538_/X _4656_/X _5578_/Y _5499_/X _5574_/X _5579_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_151_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_171 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_322 VGND VPWR sky130_fd_sc_hd__decap_12
X_7318_ _7293_/X _7289_/D _7310_/X _5932_/X _7290_/B _7318_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_132_642 VGND VPWR sky130_fd_sc_hd__decap_12
X_7249_ _7627_/Q _5924_/X _5925_/X _7245_/X _7249_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_105_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_837 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_795 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_489 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_106 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_383 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_884 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_331 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_567 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_88 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_650 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_483 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_174 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_303 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_185 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_239 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_420 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_401 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_294 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_497 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_629 VGND VPWR sky130_fd_sc_hd__fill_1
X_4950_ _7532_/Q _4950_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3901_ _6345_/B _3901_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_60_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_4881_ _7546_/Q _4881_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6620_ _4014_/X _6620_/B _6610_/C _6558_/D _6620_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_3832_ _3832_/A _3846_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_353 VGND VPWR sky130_fd_sc_hd__decap_8
X_6551_ _6553_/A _6558_/B _6553_/C _6348_/X _6547_/X _6551_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_3763_ _3763_/A _3762_/X _7748_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5502_ _7329_/D _5791_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_6482_ _6477_/X _6479_/X _6480_/X _6481_/Y _6482_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_145_233 VGND VPWR sky130_fd_sc_hd__decap_8
X_3694_ _4958_/A _5083_/A _4959_/A _3695_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5433_ _5433_/A _5433_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_133_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_620 VGND VPWR sky130_fd_sc_hd__decap_12
X_5364_ _5375_/A _5339_/A _5348_/C _5296_/X _5361_/X _5364_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_114_642 VGND VPWR sky130_fd_sc_hd__decap_4
X_7103_ _7127_/A _7131_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_4315_ _4315_/A _4315_/B _7652_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_141_472 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_815 VGND VPWR sky130_fd_sc_hd__decap_8
X_5295_ _5295_/A _5859_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4246_ _4220_/X _7100_/A _4241_/X _4246_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7034_ _7034_/A _6976_/X _7034_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_19_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_4177_ _4174_/Y _4177_/B _4177_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_765 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_478 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_821 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_117 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_448 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_437 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_692 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6818_ _6813_/X _6815_/Y _6816_/X _6817_/X _6818_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XPHY_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_550 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6749_ _6743_/X _6745_/Y _6746_/X _6748_/X _6749_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XPHY_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_469 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_258 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_675 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_537 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_581 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_732 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_434 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_415 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_404 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_692 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_857 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_879 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_563 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_409 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_835 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_846 VGND VPWR sky130_fd_sc_hd__decap_8
X_4100_ _4100_/A _4110_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5080_ clb_output[0] _5096_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_548 VGND VPWR sky130_fd_sc_hd__fill_1
X_4031_ _3973_/A _4031_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_902 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_401 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_261 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_467 VGND VPWR sky130_fd_sc_hd__decap_8
X_5982_ _5979_/X _5982_/B _5982_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_24_117 VGND VPWR sky130_fd_sc_hd__decap_12
X_7721_ _3914_/Y _6315_/B _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_459 VGND VPWR sky130_fd_sc_hd__decap_8
X_4933_ _4933_/A _4933_/B _4933_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_80_779 VGND VPWR sky130_fd_sc_hd__decap_4
XANTENNA_13 east_double_in[1] VGND VPWR sky130_fd_sc_hd__diode_2
X_4864_ _4845_/X _4863_/Y _4859_/X _4864_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7652_ _7652_/D _5106_/A _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_492 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_846 VGND VPWR sky130_fd_sc_hd__decap_8
X_6603_ _6592_/X _6603_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_119_723 VGND VPWR sky130_fd_sc_hd__decap_8
X_3815_ _3805_/X _6129_/B _3794_/X _3816_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_4795_ _4792_/X _5944_/D _4780_/X _4796_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7583_ _4689_/Y _5627_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_520 VGND VPWR sky130_fd_sc_hd__decap_6
X_6534_ _6558_/A _3991_/X _6550_/A _6464_/D _6534_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_119_745 VGND VPWR sky130_fd_sc_hd__decap_12
X_3746_ _3746_/A _3746_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_20_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_542 VGND VPWR sky130_fd_sc_hd__fill_1
X_6465_ _6448_/A _6480_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_134_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_244 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_439 VGND VPWR sky130_fd_sc_hd__fill_2
X_5416_ _5416_/A _5433_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6396_ _6396_/A _6438_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5347_ _5346_/Y _5348_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_88_846 VGND VPWR sky130_fd_sc_hd__decap_4
X_5278_ _5280_/C _5280_/D _5299_/C _5277_/X _5278_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_87_367 VGND VPWR sky130_fd_sc_hd__decap_12
X_7017_ _7017_/A _7017_/B _7017_/C _6828_/D _7017_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4229_ _4229_/A _7056_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_29_902 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_581 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_607 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_201 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_256 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_68 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_531 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_586 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_556 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_544 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_109 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_43 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_356 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_838 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_787 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_798 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_459 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_245 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_481 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_147_306 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_520 VGND VPWR sky130_fd_sc_hd__decap_8
X_4580_ _5342_/B _5333_/B VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_737 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_556 VGND VPWR sky130_fd_sc_hd__decap_8
X_6250_ _6249_/X _6250_/B _6252_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_6181_ _6127_/Y _6180_/X _6181_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_115_269 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_409 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_109 VGND VPWR sky130_fd_sc_hd__decap_12
X_5201_ _5200_/X _5201_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_130_228 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_632 VGND VPWR sky130_fd_sc_hd__fill_1
X_5132_ _5124_/B north_single_in[3] _5132_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_69_323 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_367 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_518 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_475 VGND VPWR sky130_fd_sc_hd__decap_12
X_5063_ _5056_/A south_double_in[1] _4282_/Y _5063_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_57_529 VGND VPWR sky130_fd_sc_hd__decap_8
X_4014_ _4013_/Y _4014_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_37_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_724 VGND VPWR sky130_fd_sc_hd__decap_8
X_5965_ _6031_/A _5965_/B _5966_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7704_ _7704_/D _4012_/A _7703_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5896_ _5896_/A _5896_/B east_clb_input[2] VGND VPWR sky130_fd_sc_hd__nor2_4
X_4916_ _5050_/A conf_sb[30] _4917_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_33_470 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_818 VGND VPWR sky130_fd_sc_hd__decap_12
X_7635_ _4397_/Y _7161_/C _7629_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4847_ _4845_/X _4846_/Y _4836_/X _4848_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_21_632 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_687 VGND VPWR sky130_fd_sc_hd__decap_4
X_4778_ _5956_/A _5898_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7566_ _4782_/Y _5956_/A _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6517_ _6516_/X _6517_/B _6519_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_7497_ clb_input_west[6] clb_input[30] VGND VPWR sky130_fd_sc_hd__buf_2
X_3729_ _3710_/X _5823_/A _3724_/X _3730_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6448_ _6448_/A _6448_/B _7714_/Q _3960_/Y _6448_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_134_545 VGND VPWR sky130_fd_sc_hd__decap_8
X_6379_ _6251_/A _6316_/X _6380_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_115_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_442 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_348 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_551 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_85 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_587 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_418 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_873 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_1_0_0_clk clkbuf_0_clk/X clkbuf_1_0_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_7_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_770 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_784 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_123 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_197 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_852 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_746 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5750_ _4741_/A _7572_/Q _7575_/Q _5750_/D _5751_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_50_738 VGND VPWR sky130_fd_sc_hd__decap_12
X_4701_ _4696_/A conf_vcb[23] _4701_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5681_ _5681_/A _5681_/B _5673_/A _5681_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_7420_ _7420_/HI clb_output_south[2] VGND VPWR sky130_fd_sc_hd__conb_1
X_4632_ _4632_/A _4631_/X _4632_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7351_ _7287_/A _7350_/B _7351_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4563_ _4548_/A conf_vcb[48] _4563_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6302_ _7730_/Q _6267_/Y _6302_/C _6304_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_7282_ _5908_/X _7238_/X _7281_/X _7283_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4494_ _4481_/X _7407_/B _4471_/X _4494_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_144_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_375 VGND VPWR sky130_fd_sc_hd__decap_3
X_6233_ _3837_/X _6198_/X _6221_/A _6360_/D _6233_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_104_707 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_559 VGND VPWR sky130_fd_sc_hd__decap_12
X_6164_ east_double_in[1] _6360_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_58_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_795 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_635 VGND VPWR sky130_fd_sc_hd__decap_12
X_5115_ _5115_/A _5138_/B _5115_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_69_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_6095_ _6098_/A _6089_/B _5744_/A _6094_/X _6097_/A _6095_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_73_808 VGND VPWR sky130_fd_sc_hd__decap_12
X_5046_ _5050_/A conf_sb[1] _5049_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_27_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_167 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_318 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_584 VGND VPWR sky130_fd_sc_hd__decap_12
X_6997_ _6975_/B _6803_/X _6804_/X _6993_/A _6997_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_13_407 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_373 VGND VPWR sky130_fd_sc_hd__decap_12
X_5948_ _5899_/A _4804_/X _5944_/C _5948_/D _5948_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_40_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_440 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5879_ _5879_/A _5879_/B _5880_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_139_659 VGND VPWR sky130_fd_sc_hd__decap_12
X_7618_ _7618_/D _7353_/A _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7549_ _4871_/Y _7549_/Q _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_4_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_364 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_548 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_311 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_762 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_67 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_366 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_827 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_838 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_123 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_679 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_882 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_148 VGND VPWR sky130_fd_sc_hd__decap_4
Xpsn_inst_psn_buff_100 _5859_/A _7322_/B1 VGND VPWR sky130_fd_sc_hd__buf_1
Xpsn_inst_psn_buff_111 _5188_/X psn_inst_psn_buff_69/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_251 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_240 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_295 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_284 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_273 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_262 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_440 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_158 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_147 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_353 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_386 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_215 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_900 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_440 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_484 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_326 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6920_ _6946_/B _6921_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6851_ _6866_/A _6851_/B _7684_/Q _4141_/A _6851_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_22_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_727 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_576 VGND VPWR sky130_fd_sc_hd__decap_4
X_5802_ _7576_/Q _5767_/X _5801_/X _5802_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_3994_ _3981_/A conf_hcb[46] _3997_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6782_ _6781_/X _6782_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_568 VGND VPWR sky130_fd_sc_hd__decap_12
X_5733_ _5732_/X _5673_/X _5733_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5664_ _5664_/A _5663_/X _5664_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_135_106 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_670 VGND VPWR sky130_fd_sc_hd__fill_1
X_7403_ _7403_/A _7402_/Y _7404_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_4615_ _4597_/X _5469_/C _4614_/X _4615_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5595_ vertical_global[1] _5805_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_128_191 VGND VPWR sky130_fd_sc_hd__decap_12
X_7334_ _7330_/X _7331_/Y _7332_/X _7333_/Y _7336_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_4546_ _4543_/X _4545_/X _4533_/X _4547_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_145_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_323 VGND VPWR sky130_fd_sc_hd__decap_12
X_7265_ _4422_/X _7232_/X _7246_/X _7201_/D _7265_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
Xclkbuf_5_16_0_clk clkbuf_4_8_0_clk/X _7684_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_4477_ _4454_/X _7397_/A _4471_/X _4478_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_1_108 VGND VPWR sky130_fd_sc_hd__decap_12
X_6216_ _3836_/A _6218_/B _6211_/Y _6215_/Y _6216_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_131_367 VGND VPWR sky130_fd_sc_hd__decap_8
X_7196_ _7196_/A _7189_/B _7196_/C _7260_/D _7196_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6147_ _3806_/X _6158_/D _6133_/X _6146_/X _6114_/B _6147_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_100_710 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_6078_ _4896_/Y _6210_/D _6078_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_85_498 VGND VPWR sky130_fd_sc_hd__decap_8
X_5029_ _5033_/A conf_sb[5] _5029_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_392 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_181 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_404 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_459 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_662 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_73 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_342 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_161 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_760 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_900 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_218 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_410 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_307 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_381 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_4400_ _4376_/A _4400_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5380_ _5348_/A _5348_/B _5348_/C _5313_/X _5379_/A _5380_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_153_492 VGND VPWR sky130_fd_sc_hd__decap_12
X_4331_ _4344_/A conf_vcb[91] _4334_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_114_868 VGND VPWR sky130_fd_sc_hd__decap_12
X_4262_ _4252_/X _4261_/X _4241_/X _4263_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7050_ _7050_/A _7050_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_5_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_367 VGND VPWR sky130_fd_sc_hd__decap_3
X_6001_ _6001_/A _6001_/B _5990_/A _4831_/A _6001_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4193_ _6979_/A _4194_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_39_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_6903_ _6867_/A _6867_/B _6841_/C _6860_/B _6904_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_36_863 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_362 VGND VPWR sky130_fd_sc_hd__decap_4
X_6834_ _6784_/X _6786_/X _6817_/C _6833_/X _6797_/X _6834_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_50_332 VGND VPWR sky130_fd_sc_hd__decap_4
X_3977_ _7710_/Q _3977_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6765_ _6763_/X _6765_/B _6765_/X VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5716_ _5716_/A _5715_/D _5716_/C _5508_/X _5716_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_50_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_253 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_6696_ _6694_/X _6696_/B _6696_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_40_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_128 VGND VPWR sky130_fd_sc_hd__decap_8
X_5647_ _4676_/X _5613_/X _5628_/X _5791_/D _5647_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_117_662 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_907 VGND VPWR sky130_fd_sc_hd__decap_8
X_5578_ _5571_/C _5578_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_132_621 VGND VPWR sky130_fd_sc_hd__decap_12
X_7317_ _7293_/X _7317_/B _7312_/X _7317_/D _7317_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4529_ _4513_/X _5175_/B _4499_/X _4530_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_132_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_120 VGND VPWR sky130_fd_sc_hd__fill_2
X_7248_ _7184_/A _7240_/Y _7248_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_105_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_356 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_345 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_207 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_197 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_849 VGND VPWR sky130_fd_sc_hd__decap_12
X_7179_ _7181_/A _7191_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_85_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_402 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_605 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_413 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_649 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_896 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_395 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_310 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_866 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_278 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_93 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_719 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_538 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_218 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_700 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_465 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_722 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_413 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_627 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_906 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_852 VGND VPWR sky130_fd_sc_hd__decap_8
X_3900_ _3900_/A _6345_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4880_ _4872_/A conf_sb[37] _4884_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_33_855 VGND VPWR sky130_fd_sc_hd__decap_3
X_3831_ _3828_/Y _3830_/X _3831_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6550_ _6550_/A _6553_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_3762_ _3756_/X _3761_/Y _3747_/X _3762_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_20_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_527 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_398 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_550 VGND VPWR sky130_fd_sc_hd__decap_3
X_5501_ _5478_/X _5495_/B _5465_/X _4626_/X _5501_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6481_ _3955_/A _6481_/B _6481_/C _6481_/D _6481_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_3693_ _3693_/A _5083_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_145_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_459 VGND VPWR sky130_fd_sc_hd__decap_6
X_5432_ _5428_/X _5429_/Y _5430_/X _5431_/X _5432_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_126_481 VGND VPWR sky130_fd_sc_hd__decap_8
X_5363_ _5359_/X _5360_/X _5361_/X _5362_/Y _5363_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_126_492 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_632 VGND VPWR sky130_fd_sc_hd__decap_8
X_7102_ _7102_/A _7119_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4314_ _4304_/X _5107_/A _4295_/X _4315_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_113_164 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_304 VGND VPWR sky130_fd_sc_hd__fill_1
X_5294_ _5212_/X _5294_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_141_484 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_4245_ _7148_/A _7100_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7033_ _7033_/A _7031_/X _7034_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4176_ _4162_/X _6915_/A _4153_/X _4177_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_68_774 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_276 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6817_ _4106_/Y _6785_/X _6817_/C _6817_/D _6817_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_877 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_562 VGND VPWR sky130_fd_sc_hd__decap_12
X_6748_ _4072_/A _6758_/D _6744_/Y _6817_/D _6748_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_51_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_757 VGND VPWR sky130_fd_sc_hd__decap_12
X_6679_ _6654_/A _4058_/X _6688_/C _6684_/D _6679_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_124_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_131 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_687 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_381 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_446 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_825 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_93 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_6_0_clk clkbuf_4_7_0_clk/A clkbuf_4_6_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XPHY_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_215 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_575 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_462 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_335 VGND VPWR sky130_fd_sc_hd__fill_1
X_4030_ _6619_/B _6623_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_111_657 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_240 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_733 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_711 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_755 VGND VPWR sky130_fd_sc_hd__decap_8
X_5981_ _5981_/A _5981_/B _5982_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_80_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_416 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_619 VGND VPWR sky130_fd_sc_hd__fill_1
X_7720_ _7720_/D _6435_/A _7734_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_18_693 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_4932_ _4926_/X _4931_/Y _4906_/X _4933_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7651_ _7651_/D _7651_/Q _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XANTENNA_14 west_single_out[2] VGND VPWR sky130_fd_sc_hd__diode_2
X_6602_ _6602_/A _6602_/B _6602_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4863_ _4863_/A _4863_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_20_324 VGND VPWR sky130_fd_sc_hd__decap_12
X_3814_ _6158_/D _6129_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4794_ _5935_/B _5944_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_7582_ _4695_/Y _4691_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6533_ _6533_/A _6533_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3745_ _3745_/A conf_hcb[90] _3745_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6464_ _3956_/X _3962_/X _6470_/A _6464_/D _6505_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_119_779 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_757 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_256 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_267 VGND VPWR sky130_fd_sc_hd__decap_8
X_5415_ _5395_/A _5397_/B _5416_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_6395_ _6400_/A _6400_/B _6413_/A _6329_/D _6435_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_114_462 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_803 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_707 VGND VPWR sky130_fd_sc_hd__decap_6
X_5346_ _5341_/A _5346_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_141_270 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_123 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_5277_ _5987_/A _5277_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_87_379 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_346 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_508 VGND VPWR sky130_fd_sc_hd__fill_2
X_7016_ _7016_/A _7016_/B _7016_/C _7013_/B _7016_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4228_ _4228_/A _4229_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_29_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4159_ _4159_/A _4158_/X _4159_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_83_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_213 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_825 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_696 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_836 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_368 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_327 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_552 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_213 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_427 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_652 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_749 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_6180_ _6177_/Y _6179_/X _6180_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5200_ _5200_/A _5200_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_42_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5131_ _7752_/Q _5129_/Y _5130_/X _5131_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_96_154 VGND VPWR sky130_fd_sc_hd__fill_2
X_5062_ _5059_/A _7284_/A _5062_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4013_ _4012_/X _4013_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_111_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_828 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_327 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_917 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_747 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_202 VGND VPWR sky130_fd_sc_hd__decap_12
X_7703_ _4022_/Y _7703_/Q _7703_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5964_ _5964_/A _5965_/B _5964_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5895_ _6034_/A _5827_/X _5896_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4915_ cset _4915_/B _4917_/B VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_611 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_482 VGND VPWR sky130_fd_sc_hd__decap_6
X_7634_ _4404_/Y _7189_/B _7629_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4846_ _7554_/Q _4846_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_33_493 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_830 VGND VPWR sky130_fd_sc_hd__decap_12
X_7565_ _4787_/Y _5901_/A _7618_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_6516_ _6515_/Y _6514_/X _6516_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_107_705 VGND VPWR sky130_fd_sc_hd__decap_12
X_4777_ _4771_/A conf_vcb[9] _4777_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_351 VGND VPWR sky130_fd_sc_hd__decap_12
X_7496_ clb_input_west[5] clb_input[29] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_106_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_204 VGND VPWR sky130_fd_sc_hd__decap_8
X_3728_ _3728_/A _5823_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_146_395 VGND VPWR sky130_fd_sc_hd__fill_2
X_6447_ _6446_/Y _6445_/X clb_input[3] VGND VPWR sky130_fd_sc_hd__nor2_4
X_6378_ _6377_/X _6316_/X _6380_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_0_526 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_537 VGND VPWR sky130_fd_sc_hd__decap_12
X_5329_ _7223_/A _5260_/X _5330_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_102_454 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_319 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_574 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_235 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_791 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_493 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_699 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_855 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_310 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_384 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_898 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_741 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_806 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_669 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_349 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_883 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_500 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_605 VGND VPWR sky130_fd_sc_hd__decap_12
X_5680_ _5715_/D _5681_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4700_ _4696_/Y _4699_/X _7581_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_129_830 VGND VPWR sky130_fd_sc_hd__decap_12
X_4631_ _4624_/X _4630_/Y _4614_/X _4631_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_30_441 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_800 VGND VPWR sky130_fd_sc_hd__decap_12
X_7350_ _7349_/X _7350_/B _7350_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_7_670 VGND VPWR sky130_fd_sc_hd__fill_1
X_4562_ _4558_/Y _4562_/B _7606_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6301_ _6301_/A _6300_/Y _6302_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_7281_ _7239_/Y _7280_/X _7281_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4493_ _4492_/X _7407_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6232_ _3847_/Y _6232_/B _6228_/C _6224_/B _6232_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_69_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_741 VGND VPWR sky130_fd_sc_hd__decap_8
X_6163_ _6124_/A _6179_/B _6163_/C _6163_/D _6163_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_85_603 VGND VPWR sky130_fd_sc_hd__decap_6
X_5114_ _4328_/A _5055_/A _5114_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6094_ _7746_/Q _6090_/X _6093_/Y _6094_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_85_647 VGND VPWR sky130_fd_sc_hd__decap_6
X_5045_ _5042_/Y _5044_/X _7511_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_352 VGND VPWR sky130_fd_sc_hd__decap_8
X_6996_ _6985_/X _6996_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_25_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_385 VGND VPWR sky130_fd_sc_hd__decap_12
X_5947_ _5944_/C _5944_/D _5914_/X _5871_/X _5944_/X _5947_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_53_577 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_7617_ _4495_/Y _7353_/B _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_5878_ _5832_/X _5834_/X _5864_/Y _5877_/X _5873_/X _5879_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4829_ _5981_/B _5991_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_7548_ _7548_/D _7548_/Q _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7479_ _7479_/HI north_clb_input[31] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_135_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_354 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_579 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_376 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_86 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_251 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_463 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_74 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_691 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_680 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_894 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_886 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_101 psn_inst_psn_buff_105/X psn_inst_psn_buff_64/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_252 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_241 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_230 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_285 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_274 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_263 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_115 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_296 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_496 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_445 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_434 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_696 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_571 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_124 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_338 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_499 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_179 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_820 VGND VPWR sky130_fd_sc_hd__decap_4
X_6850_ _6850_/A _6848_/X north_clb_input[5] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_47_393 VGND VPWR sky130_fd_sc_hd__decap_12
X_6781_ _4117_/Y _6811_/D _6781_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_90_694 VGND VPWR sky130_fd_sc_hd__decap_8
X_5801_ _5799_/X _5800_/Y _5801_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_149_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_3993_ _3988_/Y _3993_/B _3993_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_22_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_5732_ _5732_/A _5732_/B _5732_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5663_ _5661_/Y _5663_/B _5663_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_7402_ _7370_/A _7370_/B _7370_/C _5177_/X _7372_/X _7402_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4614_ _4499_/A _4614_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5594_ _5594_/A _5594_/B _5594_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_117_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_7333_ _4449_/X _7297_/A _7299_/A _7333_/D _7333_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4545_ _4544_/Y _4545_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_7264_ _7243_/X _4439_/A _7230_/X _4429_/X _7264_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4476_ _7383_/A _7397_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6215_ _6215_/A1 _6212_/Y _6214_/Y _6215_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_131_335 VGND VPWR sky130_fd_sc_hd__decap_8
X_7195_ _7163_/A _4411_/X _7189_/A _4401_/Y _7195_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_112_560 VGND VPWR sky130_fd_sc_hd__decap_3
X_6146_ _6145_/Y _6146_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_38_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_722 VGND VPWR sky130_fd_sc_hd__decap_12
X_6077_ _4900_/Y _4904_/A _5313_/X _6075_/X _6076_/X north_double_out[0] VGND VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_72_127 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_511 VGND VPWR sky130_fd_sc_hd__decap_8
X_5028_ _5025_/Y _5028_/B _7515_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_54_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_544 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_160 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_193 VGND VPWR sky130_fd_sc_hd__decap_6
X_6979_ _6979_/A _7016_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_154_416 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_67 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_346 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_571 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_77 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_606 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_500 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_190 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_611 VGND VPWR sky130_fd_sc_hd__decap_12
X_4330_ _4330_/A _4330_/B _4330_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_132 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_184 VGND VPWR sky130_fd_sc_hd__decap_4
X_4261_ _7127_/B _4261_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_154 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_379 VGND VPWR sky130_fd_sc_hd__decap_8
X_6000_ _5975_/A _4821_/A _6008_/A _5932_/X _5971_/B _6000_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_4192_ _6975_/C _6979_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_94_241 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_606 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_820 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_447 VGND VPWR sky130_fd_sc_hd__decap_8
X_6902_ _6902_/A _6902_/B _6904_/A VGND VPWR sky130_fd_sc_hd__nand2_4
X_6833_ west_double_in[2] _6833_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_63_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_160 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_694 VGND VPWR sky130_fd_sc_hd__decap_8
X_3976_ _3959_/A conf_hcb[49] _3979_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6764_ _6720_/A _6720_/B _6744_/Y _6502_/X _6728_/X _6765_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XPHY_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_6695_ _6652_/A _6652_/B _6676_/Y _6502_/X _6660_/X _6696_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_31_580 VGND VPWR sky130_fd_sc_hd__decap_12
X_5715_ _5715_/A _5715_/B _5715_/C _5715_/D _5715_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_148_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_265 VGND VPWR sky130_fd_sc_hd__decap_8
X_5646_ _5637_/C _5637_/D _5611_/X _4683_/X _5646_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_148_287 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_652 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_803 VGND VPWR sky130_fd_sc_hd__decap_12
X_5577_ _5572_/X _5573_/Y _5574_/X _5576_/X _5577_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_7316_ _7316_/A _7299_/A _7314_/X _7317_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_2_429 VGND VPWR sky130_fd_sc_hd__decap_12
X_4528_ _5234_/B _5175_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_633 VGND VPWR sky130_fd_sc_hd__decap_8
X_7247_ _4422_/X _4429_/X _7246_/X _7247_/D _7273_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_4459_ _4463_/A conf_vcb[66] _4459_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_49_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_368 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_7178_ _7167_/X _7169_/X _7196_/C _7242_/D _7178_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6129_ _6129_/A _6129_/B _6122_/A _6329_/D _6129_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_100_541 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_274 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_425 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_47 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_119 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_86 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_834 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_878 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_408 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_451 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_462 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_230 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_617 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_469 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_842 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_672 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_5_15_0_clk clkbuf_4_7_0_clk/X _7559_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_32_300 VGND VPWR sky130_fd_sc_hd__decap_12
X_3830_ _3805_/X _6192_/A _3825_/X _3830_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_60_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_889 VGND VPWR sky130_fd_sc_hd__decap_3
X_3761_ _3761_/A _3761_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_146_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_5500_ _5465_/X _4626_/X _5498_/Y _5499_/X _5495_/X _5500_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6480_ _3956_/A _7713_/Q _6480_/C _6480_/D _6480_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_118_427 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_3692_ _3702_/A conf_hcb[101] _3692_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_9_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_257 VGND VPWR sky130_fd_sc_hd__decap_4
X_5431_ _5431_/A _5423_/B _5412_/C _5223_/X _5431_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_133_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_5362_ _5359_/A _5362_/B _5368_/A _5203_/X _5362_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_7101_ _7101_/A _7101_/B _7102_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4313_ _5106_/A _5107_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_99_377 VGND VPWR sky130_fd_sc_hd__decap_8
X_7032_ _7156_/A _6984_/X _7033_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5293_ _5289_/X _5290_/X _5291_/X _5292_/Y _5293_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4244_ _4218_/X conf_hcb[4] _4244_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_110_861 VGND VPWR sky130_fd_sc_hd__decap_12
X_4175_ _6930_/A _6915_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_68_764 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_712 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_745 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_244 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_609 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_480 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6816_ _4117_/Y _6811_/D _6821_/C _6812_/B _6816_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_653 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_675 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_541 VGND VPWR sky130_fd_sc_hd__decap_8
X_6747_ _6416_/A _6817_/D VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_3959_ _3959_/A conf_hcb[52] _3959_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_149_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_6678_ _6672_/A _6688_/D _6676_/Y _6677_/X _6672_/X _6678_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_137_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_5629_ _4676_/X _4683_/X _5628_/X _5848_/D _5655_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_152_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_241 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_712 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_628 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_439 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_845 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_620 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_89 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_642 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_94 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_703 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_227 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_496 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_550 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_233 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_222 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_907 VGND VPWR sky130_fd_sc_hd__decap_8
X_5980_ _5980_/A _5979_/X _6030_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_80_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_406 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_620 VGND VPWR sky130_fd_sc_hd__decap_12
X_4931_ _7536_/Q _4931_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4862_ _4844_/A conf_sb[41] _4865_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7650_ _4324_/Y _7650_/Q _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_32_141 VGND VPWR sky130_fd_sc_hd__decap_12
X_6601_ _4014_/X _4020_/X _6610_/C _6601_/D _6628_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_3813_ _6113_/D _6158_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4793_ _5931_/B _5935_/B VGND VPWR sky130_fd_sc_hd__inv_8
XANTENNA_15 _5932_/A VGND VPWR sky130_fd_sc_hd__diode_2
X_7581_ _7581_/D _7581_/Q _7574_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6532_ _6532_/A _6533_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_3744_ _3741_/Y _3744_/B _3744_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_369 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_224 VGND VPWR sky130_fd_sc_hd__decap_8
X_6463_ west_double_in[3] _6464_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_739 VGND VPWR sky130_fd_sc_hd__decap_12
X_5414_ _5450_/A _5450_/B _5414_/C _5414_/D _5414_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6394_ _6394_/A _6394_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_114_441 VGND VPWR sky130_fd_sc_hd__decap_12
X_5345_ _5344_/X _5345_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_102_625 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_196 VGND VPWR sky130_fd_sc_hd__decap_8
X_5276_ south_double_in[3] _5987_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_141_293 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_358 VGND VPWR sky130_fd_sc_hd__decap_8
X_7015_ _6991_/C _6994_/B _7008_/C _6824_/X _7012_/X _7015_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4227_ _7043_/A _4228_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4158_ _4133_/X _4157_/Y _4153_/X _4158_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_28_425 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_4089_ rst _4090_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_102_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_737 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_642 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_837 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_196 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_870 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_238 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_227 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_74 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_444 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_488 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_317 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_583 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_339 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_425 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_447 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_406 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_737 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_664 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_503 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_373 VGND VPWR sky130_fd_sc_hd__decap_12
X_5130_ _5130_/A _3746_/A _5125_/A _5130_/D _5130_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_35_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5061_ _5137_/B _7284_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4012_ _4012_/A _4012_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_177 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_531 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_767 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_383 VGND VPWR sky130_fd_sc_hd__decap_12
X_5963_ _5908_/X _5912_/A _5962_/X _5964_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_80_534 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_737 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_428 VGND VPWR sky130_fd_sc_hd__decap_12
X_7702_ _4026_/Y _6582_/A _7706_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_80_545 VGND VPWR sky130_fd_sc_hd__decap_8
X_4914_ _4959_/A _4914_/B _4914_/C _7540_/D VGND VPWR sky130_fd_sc_hd__nor3_4
XFILLER_53_759 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_589 VGND VPWR sky130_fd_sc_hd__fill_2
X_5894_ _5894_/A _5827_/X _5896_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_7633_ _7633_/D _7181_/A _7628_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4845_ _4819_/A _4845_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7564_ _4796_/Y _5931_/B _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_4776_ _4776_/A _4776_/B _4776_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_147_842 VGND VPWR sky130_fd_sc_hd__decap_12
X_6515_ _6184_/A _6457_/X _6515_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_533 VGND VPWR sky130_fd_sc_hd__fill_1
X_3727_ _3718_/A conf_hcb[94] _3730_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7495_ clb_input_west[4] clb_input[28] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_146_363 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_717 VGND VPWR sky130_fd_sc_hd__decap_12
X_6446_ _6251_/A _6446_/B _6446_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_599 VGND VPWR sky130_fd_sc_hd__decap_8
X_6377_ _6376_/Y _6377_/B _6377_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_115_761 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_271 VGND VPWR sky130_fd_sc_hd__decap_4
X_5328_ _5328_/A _5260_/X _5330_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_130_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_549 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_59 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_5_0_clk clkbuf_3_2_0_clk/X clkbuf_4_5_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_5259_ _7608_/Q _7607_/Q _7610_/Q _4544_/Y _5259_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_56_520 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_745 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_756 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_851 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_501 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_47 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_69 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_450 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_667 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_396 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_889 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_539 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_350 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_597 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_876 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_589 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_617 VGND VPWR sky130_fd_sc_hd__decap_12
X_4630_ _7593_/Q _4630_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_30_453 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_812 VGND VPWR sky130_fd_sc_hd__decap_12
X_6300_ _6261_/A _6261_/B _6283_/Y _6170_/X _6299_/A _6300_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4561_ _4543_/X _5340_/C _4560_/X _4562_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7280_ _7278_/Y _7279_/X _7280_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4492_ _4492_/A _4492_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6231_ _6196_/X _3843_/X _6221_/Y _6161_/X _6228_/X _6231_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6162_ _6131_/C _6129_/B _6151_/Y _6161_/X _6158_/X _6162_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_103_219 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5113_ _7329_/D south_double_out[1] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_764 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_306 VGND VPWR sky130_fd_sc_hd__decap_6
X_6093_ _5222_/X _7540_/Q _6092_/X _6093_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
X_5044_ _4911_/A _5043_/Y _5035_/X _5044_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_66_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_681 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_372 VGND VPWR sky130_fd_sc_hd__decap_8
X_6995_ _6733_/A _7017_/C _7000_/C VGND VPWR sky130_fd_sc_hd__nor2_4
X_5946_ _5941_/X _5943_/Y _5944_/X _5945_/Y _5946_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_53_589 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_729 VGND VPWR sky130_fd_sc_hd__decap_3
X_5877_ _5076_/Y _5877_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_21_420 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_239 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_4828_ _4834_/A conf_vcb[0] _4828_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7616_ _7616_/D _7616_/Q _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_672 VGND VPWR sky130_fd_sc_hd__decap_12
X_7547_ _7547_/D _4877_/A _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4759_ _4759_/A _4759_/B _7570_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7478_ _7478_/HI north_clb_input[30] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_134_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_6429_ _6425_/X _6426_/Y _6427_/X _6428_/Y _6429_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_108_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_335 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_475 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_57 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_910 VGND VPWR sky130_fd_sc_hd__decap_4
Xpsn_inst_psn_buff_102 psn_inst_psn_buff_102/A psn_inst_psn_buff_67/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_242 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_231 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_220 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_386 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_792 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_286 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_275 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_264 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_253 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_773 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_297 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_322 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_333 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_707 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_615 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_306 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_489 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_681 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_651 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_320 VGND VPWR sky130_fd_sc_hd__decap_12
X_3992_ _3982_/X _3991_/X _3973_/X _3993_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6780_ _6780_/A _6780_/B _6780_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5800_ _5759_/A _5759_/B _5767_/C _5515_/X _5769_/X _5800_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_22_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_5731_ _5526_/X _5731_/B _5732_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_31_740 VGND VPWR sky130_fd_sc_hd__decap_8
X_5662_ _5637_/C _4693_/X _5805_/C _5618_/A _5663_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_129_672 VGND VPWR sky130_fd_sc_hd__decap_12
X_7401_ _7372_/X _7375_/Y _7400_/X _7403_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4613_ _5518_/A _5469_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_5593_ _4666_/X _5318_/X _5552_/X _5546_/A _5594_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_128_171 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_823 VGND VPWR sky130_fd_sc_hd__decap_12
X_7332_ _7291_/A _4466_/X _7295_/A _7297_/A _7332_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4544_ _4544_/A _4544_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_144_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_7263_ _7230_/X _4429_/X _7262_/Y _5865_/X _7259_/X _7263_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6214_ _6212_/Y _6213_/X _6193_/X _6214_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_132_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_4475_ _7353_/C _7383_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7194_ _4395_/X _7201_/B _7196_/C _5859_/X _7191_/X _7194_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_98_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_6145_ west_single_in[0] _6145_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_773 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_734 VGND VPWR sky130_fd_sc_hd__decap_12
X_6076_ _7542_/Q east_double_in[2] _4904_/Y _6076_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_57_158 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_862 VGND VPWR sky130_fd_sc_hd__decap_12
X_5027_ _5021_/X _5026_/Y _5012_/X _5028_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_54_832 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_139 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_589 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_6978_ _6977_/X _7017_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_139_414 VGND VPWR sky130_fd_sc_hd__fill_2
X_5929_ _5929_/A _5929_/B _5930_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_139_458 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_447 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_469 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_428 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_171 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_388 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_196 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_434 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_437 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_512 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_350 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_523 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_534 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_673 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_876 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_815 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_526 VGND VPWR sky130_fd_sc_hd__decap_3
X_4260_ _4260_/A _7127_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_4191_ _4104_/A _4191_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_140_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_220 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_445 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_459 VGND VPWR sky130_fd_sc_hd__decap_4
X_6901_ _6867_/B _6837_/X _6867_/A _6860_/B _6902_/B VGND VPWR sky130_fd_sc_hd__a211o_4
X_6832_ _6797_/X _6832_/B _6832_/C _6835_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_63_662 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_504 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_846 VGND VPWR sky130_fd_sc_hd__decap_8
X_3975_ _3975_/A _3974_/X _7711_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6763_ _6728_/X _6731_/Y _6763_/C _6763_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_23_559 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_233 VGND VPWR sky130_fd_sc_hd__decap_8
X_6694_ _6660_/X _6664_/Y _6693_/X _6694_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_5714_ _5715_/C _5711_/D _5689_/C _5505_/X _5711_/X _5714_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5645_ _5611_/X _4683_/X _5644_/Y _5499_/X _5641_/X _5645_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_31_592 VGND VPWR sky130_fd_sc_hd__fill_1
X_5576_ _5576_/A _7589_/Q _5576_/C _5862_/D _5576_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_116_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_815 VGND VPWR sky130_fd_sc_hd__decap_8
X_7315_ _7301_/B _7315_/B _7316_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4527_ _5194_/B _5234_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_7246_ _7245_/X _7246_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4458_ _4453_/Y _4457_/X _7624_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_49_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_678 VGND VPWR sky130_fd_sc_hd__decap_12
X_7177_ _7184_/B _7196_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_6128_ west_double_in[3] _6329_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4389_ _4389_/A _7162_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_581 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_553 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_445 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_88 VGND VPWR sky130_fd_sc_hd__decap_8
X_6059_ _5039_/A south_single_in[0] _5043_/Y _6059_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_73_448 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_651 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_492 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_36 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_25 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_323 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_258 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_236 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_130 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_656 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_623 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_196 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_474 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_459 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_342 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_492 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_898 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_312 VGND VPWR sky130_fd_sc_hd__decap_12
X_3760_ _3760_/A conf_hcb[87] _3763_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_60_676 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_378 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_439 VGND VPWR sky130_fd_sc_hd__fill_2
X_3691_ _3691_/A _3690_/X _7763_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5430_ _5439_/A _5435_/B _5423_/A _5427_/B _5430_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_65_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_409 VGND VPWR sky130_fd_sc_hd__fill_1
X_5361_ _5361_/A _5359_/B _5350_/A _5370_/B _5361_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_113_111 VGND VPWR sky130_fd_sc_hd__decap_8
X_7100_ _7100_/A _7100_/B _7158_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4312_ _4321_/A conf_vcb[95] _4315_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5292_ _5289_/A _4544_/Y _5282_/X _5203_/X _5292_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_114_667 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_367 VGND VPWR sky130_fd_sc_hd__decap_3
X_7031_ _7031_/A _6984_/X _7031_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4243_ _4236_/Y _4243_/B _4243_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_141_497 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_306 VGND VPWR sky130_fd_sc_hd__decap_6
X_4174_ _4161_/A conf_hcb[16] _4174_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_110_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_629 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_212 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6815_ _4106_/Y _6785_/X _6817_/C _6677_/X _6811_/X _6815_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XPHY_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_665 VGND VPWR sky130_fd_sc_hd__decap_6
X_6746_ _6722_/A _4087_/X _6758_/C _4077_/X _6746_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_367 VGND VPWR sky130_fd_sc_hd__decap_12
X_3958_ _3951_/Y _3957_/X _7714_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_51_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_586 VGND VPWR sky130_fd_sc_hd__decap_12
X_3889_ _3886_/Y _3888_/X _3889_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_109_428 VGND VPWR sky130_fd_sc_hd__decap_3
X_6677_ _6677_/A _6677_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5628_ _5628_/A _5628_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_461 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_450 VGND VPWR sky130_fd_sc_hd__decap_8
X_5559_ _5773_/A _5559_/B _5559_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_151_228 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_507 VGND VPWR sky130_fd_sc_hd__decap_12
X_7229_ _7225_/C _7229_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_74_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_253 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_607 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_426 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_459 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_640 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_312 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_816 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_84 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_715 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_500 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_584 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_291 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_337 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_529 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_761 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_651 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_727 VGND VPWR sky130_fd_sc_hd__decap_4
X_4930_ _4934_/A conf_sb[27] _4933_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4861_ _4857_/Y _4861_/B _7551_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_33_632 VGND VPWR sky130_fd_sc_hd__decap_3
X_6600_ _6599_/X _6610_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_3812_ _3812_/A _6113_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_4792_ _4819_/A _4792_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_7580_ _4705_/Y _5672_/C _7574_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_501 VGND VPWR sky130_fd_sc_hd__decap_12
X_6531_ _6528_/X _6531_/B _6532_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_3743_ _3733_/X _5130_/A _3724_/X _3744_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_146_534 VGND VPWR sky130_fd_sc_hd__decap_8
X_6462_ _6461_/X _6512_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6393_ _6392_/X _6394_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5413_ _5395_/A _5450_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_217 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_5344_ _5344_/A _5344_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_142_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_453 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_326 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_304 VGND VPWR sky130_fd_sc_hd__fill_1
X_5275_ _5284_/B _5299_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_7014_ _7009_/X _7011_/Y _7012_/X _7013_/Y _7014_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4226_ _4218_/X conf_hcb[7] _4231_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_96_882 VGND VPWR sky130_fd_sc_hd__decap_3
X_4157_ _7680_/Q _4157_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_29_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_4088_ _4087_/X _6769_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_83_554 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_245 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_56 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_654 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_495 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_350 VGND VPWR sky130_fd_sc_hd__decap_12
X_6729_ _4082_/A _4086_/Y _6729_/X VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_893 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_578 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_567 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_291 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_86 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_14_0_clk clkbuf_4_7_0_clk/X _7618_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_120_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_702 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_74 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_5_29_0_clk clkbuf_5_29_0_clk/A _7732_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_46_223 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_515 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_128_578 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_228 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_315 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_145 VGND VPWR sky130_fd_sc_hd__decap_8
X_5060_ east_clb_output[0] _5137_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4011_ _3953_/A _4011_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_111_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_90 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_510 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_245 VGND VPWR sky130_fd_sc_hd__decap_12
X_5962_ _5912_/Y _5961_/X _5962_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_52_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_7701_ _4033_/Y _6582_/B _7703_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_92_395 VGND VPWR sky130_fd_sc_hd__fill_2
X_4913_ _5050_/A conf_sb[31] _4914_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_52_248 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_790 VGND VPWR sky130_fd_sc_hd__decap_8
X_5893_ _5892_/Y _5891_/X _5894_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_21_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_440 VGND VPWR sky130_fd_sc_hd__decap_8
X_7632_ _7632_/D _4410_/A _7628_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4844_ _4844_/A conf_sb[45] _4848_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_646 VGND VPWR sky130_fd_sc_hd__decap_8
X_7563_ _4800_/Y _5916_/A _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_657 VGND VPWR sky130_fd_sc_hd__decap_12
X_4775_ _4762_/X _5873_/B _4752_/X _4776_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6514_ _6514_/A _6457_/X _6514_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_3726_ _3722_/Y _3725_/X _3726_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_7494_ clb_input_west[3] clb_input[27] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_107_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_375 VGND VPWR sky130_fd_sc_hd__decap_12
X_6445_ _6444_/X _6446_/B _6445_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_6376_ _6248_/A _6324_/X _6376_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_115_784 VGND VPWR sky130_fd_sc_hd__decap_8
X_5327_ _5327_/A _5325_/X _5328_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_87_134 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5258_ _5257_/Y _5255_/X clb_input[11] VGND VPWR sky130_fd_sc_hd__nor2_4
X_4209_ _6992_/B _7012_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_56_532 VGND VPWR sky130_fd_sc_hd__decap_8
X_5189_ south_single_out[1] _5925_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_56_543 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_768 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_429 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_679 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_331 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_898 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_74 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_220 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_510 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_863 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_738 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_557 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_911 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_92 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4560_ _4499_/A _4560_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_30_498 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4491_ _7353_/B _4492_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_7_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_334 VGND VPWR sky130_fd_sc_hd__fill_2
X_6230_ _6225_/X _6227_/Y _6228_/X _6229_/Y _6230_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_143_367 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_518 VGND VPWR sky130_fd_sc_hd__fill_2
X_6161_ east_double_in[0] _6161_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_111_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_123 VGND VPWR sky130_fd_sc_hd__decap_8
X_5112_ _7654_/Q _5110_/Y _5111_/X _7329_/D VGND VPWR sky130_fd_sc_hd__o21ai_4
X_6092_ _4915_/B _6091_/Y _6092_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_111_275 VGND VPWR sky130_fd_sc_hd__decap_3
X_5043_ _7511_/Q _5043_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_65_340 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_693 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_727 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_738 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_181 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_866 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_855 VGND VPWR sky130_fd_sc_hd__fill_2
X_6994_ _7017_/A _6994_/B _7010_/A _6334_/A _7021_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_5945_ _4785_/X _5948_/D _5919_/X _7201_/D _5945_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_80_398 VGND VPWR sky130_fd_sc_hd__decap_6
X_5876_ _5870_/X _5872_/Y _5873_/X _5875_/Y _5879_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_33_281 VGND VPWR sky130_fd_sc_hd__decap_12
X_4827_ _4827_/A _4826_/X _7558_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7615_ _7615_/D _7615_/Q _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_487 VGND VPWR sky130_fd_sc_hd__fill_1
X_7546_ _7546_/D _7546_/Q _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4758_ _4735_/X _5869_/A _4752_/X _4759_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_5_609 VGND VPWR sky130_fd_sc_hd__fill_1
X_7477_ _7477_/HI north_clb_input[29] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_147_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_301 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_11 VGND VPWR sky130_fd_sc_hd__decap_12
X_3709_ _3804_/A _3733_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4689_ _4686_/Y _4689_/B _4689_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_135_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_334 VGND VPWR sky130_fd_sc_hd__fill_2
X_6428_ _6400_/A _6428_/B _6413_/A _6360_/D _6428_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_108_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_6359_ _3905_/Y _6359_/B _6355_/C _6321_/X _6359_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_88_443 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_432 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_454 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_649 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_619 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_874 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_727 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_74 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_210 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_103 psn_inst_psn_buff_103/A psn_inst_psn_buff_68/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_71_365 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_243 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_232 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_221 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_398 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_410 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_276 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_265 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_254 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_298 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_287 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_476 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_621 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_345 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_631 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_337 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_584 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_881 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_318 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_896 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_332 VGND VPWR sky130_fd_sc_hd__decap_4
X_3991_ _6552_/D _3991_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_16_760 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_398 VGND VPWR sky130_fd_sc_hd__decap_4
X_5730_ _5729_/Y _5731_/B _5732_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_149_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_281 VGND VPWR sky130_fd_sc_hd__decap_12
X_7400_ _7400_/A _7399_/Y _7400_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5661_ _5658_/X _5661_/B _5661_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_30_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_459 VGND VPWR sky130_fd_sc_hd__decap_12
X_4612_ _4612_/A conf_vcb[39] _4612_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5592_ _7591_/Q _5592_/B _5592_/C _5594_/A VGND VPWR sky130_fd_sc_hd__or3_4
Xclkbuf_4_4_0_clk clkbuf_3_2_0_clk/X clkbuf_5_9_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_129_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_835 VGND VPWR sky130_fd_sc_hd__decap_12
X_7331_ _7295_/A _4456_/X _7306_/C _5104_/X _7328_/X _7331_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4543_ _4512_/X _4543_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_879 VGND VPWR sky130_fd_sc_hd__decap_12
X_7262_ _7246_/X _7262_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6213_ _6191_/B _6138_/X _6140_/X _6208_/X _6213_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_116_378 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_507 VGND VPWR sky130_fd_sc_hd__decap_12
X_4474_ _4463_/A conf_vcb[63] _4478_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_132_849 VGND VPWR sky130_fd_sc_hd__decap_12
X_7193_ _7189_/X _7190_/X _7191_/X _7192_/Y _7193_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6144_ _3806_/X _3812_/A _6144_/C _6144_/D _6144_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_98_785 VGND VPWR sky130_fd_sc_hd__decap_12
X_6075_ _4900_/Y _6210_/D _6075_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_100_768 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_746 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_457 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_340 VGND VPWR sky130_fd_sc_hd__decap_8
X_5026_ _7515_/Q _5026_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_39_874 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_885 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_652 VGND VPWR sky130_fd_sc_hd__decap_8
X_6977_ _7016_/A _7012_/B _6977_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_81_696 VGND VPWR sky130_fd_sc_hd__decap_12
X_5928_ _5928_/A _7251_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_53_376 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_49 VGND VPWR sky130_fd_sc_hd__fill_2
X_5859_ _5859_/A _5859_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_428 VGND VPWR sky130_fd_sc_hd__decap_12
X_7529_ _4963_/Y _4961_/A _7529_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_107_334 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_367 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_47 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_660 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_373 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_546 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_844 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_398 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_142 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_4190_ _4189_/X conf_hcb[13] _4196_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_178 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_273 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_766 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_276 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_619 VGND VPWR sky130_fd_sc_hd__fill_2
X_6900_ _4128_/A _6865_/Y _6900_/C _6902_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_54_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_855 VGND VPWR sky130_fd_sc_hd__decap_8
X_6831_ _6831_/A _6830_/Y _6832_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_90_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_516 VGND VPWR sky130_fd_sc_hd__decap_4
X_3974_ _3953_/X _3972_/X _3973_/X _3974_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6762_ _6760_/X _6761_/Y _6763_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_50_346 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_858 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_223 VGND VPWR sky130_fd_sc_hd__fill_1
X_6693_ _6690_/X _6692_/Y _6693_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_5713_ _5708_/X _5710_/Y _5711_/X _5712_/Y _5713_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5644_ _5628_/X _5644_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_136_429 VGND VPWR sky130_fd_sc_hd__decap_12
X_7314_ _7309_/A _4465_/X _7313_/X _7314_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5575_ _5939_/A _5862_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4526_ _5164_/A _5194_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_131_123 VGND VPWR sky130_fd_sc_hd__decap_6
X_7245_ _7628_/Q _4437_/Y _7245_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_104_337 VGND VPWR sky130_fd_sc_hd__decap_8
X_4457_ _4454_/X _4456_/X _4444_/X _4457_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7176_ _7164_/X _7184_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_49_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_6127_ _6126_/X _6127_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4388_ _4384_/A conf_vcb[79] _4388_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_85_210 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_435 VGND VPWR sky130_fd_sc_hd__fill_1
X_6058_ _6058_/A north_single_in[1] _6058_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5009_ _5009_/A _5009_/B _5009_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_54_663 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_685 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_302 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_379 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_245 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_593 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_440 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_668 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_808 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_189 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_370 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_703 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_276 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_213 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_268 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_257 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_652 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_471 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_825 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_699 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_81 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_3690_ _4958_/A _3687_/Y _4959_/A _3690_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_58_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5360_ _5359_/A _5362_/B _5368_/A _5197_/X _5332_/B _5360_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_114_646 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_313 VGND VPWR sky130_fd_sc_hd__decap_12
X_4311_ _4308_/Y _4310_/X _7653_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_5_781 VGND VPWR sky130_fd_sc_hd__decap_12
X_5291_ _4537_/Y _4544_/A _5279_/X _4554_/X _5291_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_114_679 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_156 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_508 VGND VPWR sky130_fd_sc_hd__decap_12
X_4242_ _4220_/X _7078_/B _4241_/X _4243_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7030_ _6789_/X _6988_/A _7029_/X _7031_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4173_ _4168_/Y _4172_/X _7678_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_67_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_210 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_917 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_780 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_460 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_847 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_611 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6814_ _6782_/X _6817_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_35_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_3957_ _3953_/X _3956_/X _3942_/X _3957_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6745_ _4072_/A _6758_/D _6744_/Y _6677_/X _6741_/X _6745_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XPHY_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_379 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_598 VGND VPWR sky130_fd_sc_hd__decap_12
X_3888_ _3863_/X _3887_/Y _3883_/X _3888_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6676_ _6658_/C _6676_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5627_ _5627_/A _4691_/Y _5628_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5558_ _5922_/A _5773_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_132_410 VGND VPWR sky130_fd_sc_hd__fill_2
X_4509_ _4372_/A _4510_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_292 VGND VPWR sky130_fd_sc_hd__decap_12
X_7228_ _7227_/X _7228_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_5489_ _5491_/A _4625_/Y _5491_/C _5197_/X _5461_/B _5489_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_116_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_178 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_830 VGND VPWR sky130_fd_sc_hd__decap_12
X_7159_ _7159_/A _7158_/B _7159_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_47_906 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_340 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_552 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_373 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_791 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_471 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_633 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_379 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_677 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_85 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_727 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_462 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_806 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_649 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_663 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_780 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_674 VGND VPWR sky130_fd_sc_hd__decap_12
X_4860_ _4845_/X _4858_/Y _4859_/X _4861_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_3811_ _3803_/A conf_hcb[77] _3811_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_82_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_806 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_6530_ _6552_/A _6520_/B _6531_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4791_ _3681_/X _4819_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_513 VGND VPWR sky130_fd_sc_hd__decap_6
X_3742_ _7752_/Q _5130_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_20_349 VGND VPWR sky130_fd_sc_hd__decap_3
X_6461_ _6461_/A _6461_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6392_ _6389_/X _6392_/B _6392_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5412_ _5414_/C _5414_/D _5412_/C _5277_/X _5447_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_154_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_229 VGND VPWR sky130_fd_sc_hd__decap_12
X_5343_ _5343_/A _5343_/B _5344_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5274_ _5262_/X _5284_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_114_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_338 VGND VPWR sky130_fd_sc_hd__decap_8
X_7013_ _7017_/A _7013_/B _7010_/A _6754_/X _7013_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4225_ _4225_/A _4224_/X _7669_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_101_159 VGND VPWR sky130_fd_sc_hd__fill_2
X_4156_ _4139_/A conf_hcb[19] _4159_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_56_703 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_224 VGND VPWR sky130_fd_sc_hd__decap_8
X_4087_ _4086_/Y _4087_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_55_235 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_600 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_110 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_474 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4989_ _4905_/X _4989_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_149_362 VGND VPWR sky130_fd_sc_hd__decap_4
X_6728_ _6769_/A _6769_/B _6720_/A _6720_/B _6728_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6659_ _7697_/Q _6700_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_109_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_515 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_432 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_424 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_693 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_599 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_791 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_493 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_430 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_772 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_614 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_669 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_581 VGND VPWR sky130_fd_sc_hd__decap_12
X_4010_ _4017_/A conf_hcb[43] _4016_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_725 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_747 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_257 VGND VPWR sky130_fd_sc_hd__decap_12
X_5961_ _5958_/Y _5961_/B _5961_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_25_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_7700_ _4037_/Y _7700_/Q _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4912_ _3733_/A _5050_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_52_227 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_482 VGND VPWR sky130_fd_sc_hd__decap_8
X_7631_ _4419_/Y _4416_/A _7628_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_61_750 VGND VPWR sky130_fd_sc_hd__decap_12
X_5892_ _6031_/A _5836_/X _5892_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4843_ _4843_/A _4844_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_21_636 VGND VPWR sky130_fd_sc_hd__fill_1
X_7562_ _7562_/D _4802_/A _7559_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_669 VGND VPWR sky130_fd_sc_hd__fill_2
X_4774_ _5867_/B _5873_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_7493_ clb_input_west[2] clb_input[26] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_147_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_6513_ _6458_/X _6461_/X _6512_/X _6514_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_3725_ _3710_/X _3723_/Y _3724_/X _3725_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_134_505 VGND VPWR sky130_fd_sc_hd__decap_12
X_6444_ _6444_/A _6444_/B _6444_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_119_557 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_387 VGND VPWR sky130_fd_sc_hd__decap_8
X_6375_ _6375_/A _6324_/X _6377_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_114_240 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_102 VGND VPWR sky130_fd_sc_hd__fill_2
X_5326_ _7220_/A _5269_/X _5327_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_87_113 VGND VPWR sky130_fd_sc_hd__decap_8
X_5257_ _7223_/A _5255_/B _5257_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_130_788 VGND VPWR sky130_fd_sc_hd__decap_12
X_4208_ _6975_/B _6992_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_57_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_382 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_202 VGND VPWR sky130_fd_sc_hd__decap_12
X_5188_ _5922_/A _5188_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4139_ _4139_/A conf_hcb[22] _4144_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_44_706 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_780 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_814 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_505 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_614 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_733 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_135 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_157 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_308 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_801 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_452 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_794 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_433 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_310 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_505 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_398 VGND VPWR sky130_fd_sc_hd__decap_12
X_4490_ _4479_/X conf_vcb[60] _4495_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_10_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_6160_ _6155_/X _6157_/Y _6158_/X _6159_/Y _6160_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_40_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5111_ _5111_/A _4309_/A _5106_/A _5111_/D _5111_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_112_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_232 VGND VPWR sky130_fd_sc_hd__fill_1
X_6091_ _7540_/Q north_single_in[2] _6091_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_111_287 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_127 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_691 VGND VPWR sky130_fd_sc_hd__decap_8
X_5042_ _5050_/A conf_sb[2] _5042_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_503 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_193 VGND VPWR sky130_fd_sc_hd__decap_4
X_6993_ _6993_/A _7010_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_81_878 VGND VPWR sky130_fd_sc_hd__decap_12
X_5944_ _5916_/X _4803_/X _5944_/C _5944_/D _5944_/X VGND VPWR sky130_fd_sc_hd__and4_4
Xclkbuf_5_13_0_clk clkbuf_4_6_0_clk/X _7657_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_5875_ _5869_/A _5869_/B _5875_/C _7269_/D _5875_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_61_580 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_608 VGND VPWR sky130_fd_sc_hd__fill_2
X_4826_ _4819_/X _5981_/A _4809_/X _4826_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_21_444 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_293 VGND VPWR sky130_fd_sc_hd__decap_12
X_7614_ _7614_/D _7614_/Q _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7545_ _7545_/D _5091_/A _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_343 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_332 VGND VPWR sky130_fd_sc_hd__decap_8
X_4757_ _5862_/A _5869_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_151 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_5_28_0_clk clkbuf_5_29_0_clk/A _7734_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_7476_ _7476_/HI north_clb_input[28] VGND VPWR sky130_fd_sc_hd__conb_1
X_4688_ _4681_/X _5608_/A _4671_/X _4689_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_3708_ _3681_/X _3804_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_134_346 VGND VPWR sky130_fd_sc_hd__decap_8
X_6427_ _6427_/A _6397_/B _6386_/A _6424_/B _6427_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_108_23 VGND VPWR sky130_fd_sc_hd__decap_8
X_6358_ _6320_/X _3901_/X _6351_/C _6161_/X _6355_/X _6358_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_143_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_733 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_422 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_304 VGND VPWR sky130_fd_sc_hd__decap_6
X_5309_ _5305_/X _5306_/Y _5307_/X _5308_/Y _5311_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_124_11 VGND VPWR sky130_fd_sc_hd__decap_12
X_6289_ _6258_/A _6272_/B _6288_/Y west_double_out[0] _6285_/X _6289_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_76_617 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_308 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_119 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_801 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_856 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_385 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_227 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_200 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_750 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_233 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_222 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_104 _5928_/A psn_inst_psn_buff_75/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_277 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_266 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_107 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_255 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_244 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_299 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_288 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_611 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_633 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_519 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_219 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_593 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_530 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_455 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_639 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_893 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_93 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_661 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_300 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_886 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_182 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_536 VGND VPWR sky130_fd_sc_hd__fill_2
X_3990_ _3990_/A _6552_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_63_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_293 VGND VPWR sky130_fd_sc_hd__decap_12
X_5660_ _4693_/X _5659_/X _5637_/C _5618_/A _5661_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_88_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_4611_ _4606_/Y _4611_/B _7597_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_30_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_630 VGND VPWR sky130_fd_sc_hd__decap_12
X_5591_ _5589_/X _5590_/Y _5592_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_129_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_151 VGND VPWR sky130_fd_sc_hd__fill_2
X_7330_ _7325_/X _7327_/Y _7328_/X _7329_/Y _7330_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4542_ _4548_/A conf_vcb[52] _4547_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_143_132 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_847 VGND VPWR sky130_fd_sc_hd__decap_6
X_7261_ _7257_/X _7258_/Y _7259_/X _7260_/X _7261_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4473_ _4469_/Y _4472_/X _7621_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_144_666 VGND VPWR sky130_fd_sc_hd__decap_12
X_6212_ _6212_/A _6212_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_125_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_7192_ _7189_/A _4401_/Y _7182_/X _7192_/D _7192_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_140_861 VGND VPWR sky130_fd_sc_hd__decap_12
X_6143_ _6143_/A1 _6136_/Y _6142_/Y _6144_/D VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_97_252 VGND VPWR sky130_fd_sc_hd__decap_8
X_6074_ _6334_/A _6210_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_97_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_758 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_436 VGND VPWR sky130_fd_sc_hd__fill_2
X_5025_ _5033_/A conf_sb[6] _5025_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_650 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_363 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_897 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_152 VGND VPWR sky130_fd_sc_hd__fill_1
X_6976_ _4186_/Y _6976_/B _6976_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5927_ _5916_/A _4803_/X _5926_/X _5927_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_53_388 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_5858_ _5854_/X _5855_/X _5856_/X _5857_/Y _5858_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_22_764 VGND VPWR sky130_fd_sc_hd__decap_6
X_4809_ _4809_/A _4809_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5789_ _5755_/X _4737_/X _5788_/Y _5499_/X _5785_/X _5789_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_135_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_825 VGND VPWR sky130_fd_sc_hd__decap_12
X_7528_ _4968_/Y _7528_/Q _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7459_ _7459_/HI north_clb_input[11] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_134_121 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_110 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_15 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_156 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_406 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_672 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_86 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_642 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_837 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_561 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_198 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_701 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_70 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_915 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_778 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_694 VGND VPWR sky130_fd_sc_hd__decap_8
X_6830_ _6784_/X _6786_/X _6819_/Y _6691_/X _6826_/X _6830_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_35_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_889 VGND VPWR sky130_fd_sc_hd__decap_8
X_6761_ _6720_/A _6720_/B _6750_/Y _6691_/X _6758_/X _6761_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_90_483 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_826 VGND VPWR sky130_fd_sc_hd__decap_12
X_3973_ _3973_/A _3973_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5712_ _5716_/A _5715_/D _5709_/A _5791_/D _5712_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_50_358 VGND VPWR sky130_fd_sc_hd__decap_6
X_6692_ _6652_/A _6652_/B _6682_/Y _6691_/X _6688_/X _6692_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_149_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_5643_ _5639_/X _5640_/Y _5641_/X _5642_/X _5643_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_117_611 VGND VPWR sky130_fd_sc_hd__decap_12
X_5574_ _4660_/Y _5574_/B _5571_/A _4655_/Y _5574_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7313_ _4464_/A _5924_/X _5925_/X _7310_/A _7313_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_4525_ _4511_/A conf_vcb[55] _4530_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_144_485 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_198 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_187 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_176 VGND VPWR sky130_fd_sc_hd__decap_8
X_7244_ _7243_/X _4439_/X _7234_/A _7234_/B _7244_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4456_ _7289_/D _4456_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4387_ _4387_/A _4386_/X _7637_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7175_ _7174_/X _7175_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6126_ _6125_/X _6126_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_86_701 VGND VPWR sky130_fd_sc_hd__fill_1
X_6057_ _6055_/A _7509_/Q south_single_in[0] _6055_/X _6056_/X north_single_out[0]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_27_812 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_661 VGND VPWR sky130_fd_sc_hd__decap_8
X_5008_ _4998_/X _5007_/Y _4989_/X _5009_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_26_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_163 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_506 VGND VPWR sky130_fd_sc_hd__decap_12
X_6959_ _6929_/X _6932_/Y _6958_/X _6961_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_53_196 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_422 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_443 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_360 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_382 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_767 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_778 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_3_0_clk clkbuf_4_3_0_clk/A clkbuf_5_7_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_18_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_225 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_203 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_834 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_290 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_325 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_303 VGND VPWR sky130_fd_sc_hd__fill_2
X_4310_ _4304_/X _4309_/Y _4295_/X _4310_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5290_ _5289_/A _4544_/Y _5282_/X _5197_/X _5259_/X _5290_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_4241_ _4272_/A _4241_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4172_ _4162_/X _4171_/X _4153_/X _4172_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_110_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_266 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_439 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_258 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_491 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_792 VGND VPWR sky130_fd_sc_hd__fill_1
X_6813_ _6808_/X _6810_/X _6811_/X _6812_/Y _6813_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_90_291 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_3956_ _3956_/A _3956_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6744_ _6721_/A _6744_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_6675_ _6670_/X _6671_/X _6672_/X _6674_/Y _6675_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3887_ _7725_/Q _3887_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5626_ _5637_/C _4693_/X _5615_/A _5615_/B _5626_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_31_391 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_249 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_5557_ _5581_/A _4656_/X _5571_/C _5848_/D _5589_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_145_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_282 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_102 VGND VPWR sky130_fd_sc_hd__decap_8
X_4508_ _4508_/A _4508_/B _7615_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5488_ _5491_/A _7594_/Q _5488_/C _5487_/X _5488_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4439_ _4439_/A _4439_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7227_ _4433_/Y _4437_/Y _7227_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_132_488 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_842 VGND VPWR sky130_fd_sc_hd__decap_12
X_7158_ _7157_/X _7158_/B _7160_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_58_222 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_330 VGND VPWR sky130_fd_sc_hd__decap_6
X_6109_ _6109_/A _5096_/B _6109_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_7089_ _7074_/A _7078_/B _6841_/C _7045_/X _7090_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_132_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_288 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_910 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_483 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_86 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_739 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_219 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_474 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_317 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_296 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_60 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_631 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_589 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_3810_ _3810_/A _3809_/X _7739_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_4790_ _4807_/A conf_vcb[7] _4796_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_689 VGND VPWR sky130_fd_sc_hd__decap_12
X_3741_ _3745_/A conf_hcb[91] _3741_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_32_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_205 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_391 VGND VPWR sky130_fd_sc_hd__decap_6
X_6460_ _6456_/X _6459_/X _6461_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_70_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_569 VGND VPWR sky130_fd_sc_hd__decap_8
X_6391_ _6427_/A _6381_/B _6392_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_5411_ _5410_/Y _5412_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_127_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_100 VGND VPWR sky130_fd_sc_hd__fill_2
X_5342_ _5342_/A _5342_/B _5343_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_99_144 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_306 VGND VPWR sky130_fd_sc_hd__fill_1
X_7012_ _7012_/A _7012_/B _7016_/C _7012_/D _7012_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5273_ _5272_/X _5273_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_141_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_840 VGND VPWR sky130_fd_sc_hd__decap_3
X_4224_ _4220_/X _7075_/A _4211_/X _4224_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_96_862 VGND VPWR sky130_fd_sc_hd__decap_12
X_4155_ _4149_/Y _4155_/B _4155_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_95_394 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_203 VGND VPWR sky130_fd_sc_hd__decap_8
X_4086_ _4086_/A _4086_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_52_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_612 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_450 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_306 VGND VPWR sky130_fd_sc_hd__decap_12
X_4988_ _4988_/A _4988_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3939_ _6398_/B _6422_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6727_ _4082_/A _6769_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_851 VGND VPWR sky130_fd_sc_hd__decap_8
X_6658_ _6658_/A _6658_/B _6658_/C _6464_/D _6658_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5609_ _5608_/X _5621_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6589_ _6620_/B _6589_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_411 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_455 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_285 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_309 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_672 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_523 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_417 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_98 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_217 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_239 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_626 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_503 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_458 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_394 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_707 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_759 VGND VPWR sky130_fd_sc_hd__decap_4
X_5960_ _5916_/X _4804_/X _7215_/C _5910_/A _5961_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_65_567 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_269 VGND VPWR sky130_fd_sc_hd__decap_12
X_4911_ _4911_/A _6090_/A _4914_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_5891_ _5890_/Y _5836_/X _5891_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_33_420 VGND VPWR sky130_fd_sc_hd__decap_6
X_7630_ _4424_/Y _7225_/C _7629_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_61_773 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_762 VGND VPWR sky130_fd_sc_hd__fill_2
X_4842_ _4842_/A _4841_/X _7555_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_60_250 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_497 VGND VPWR sky130_fd_sc_hd__decap_8
X_7561_ _7561_/D _6022_/A _7637_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4773_ _4773_/A _5867_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6512_ _6512_/A _6512_/B _6512_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_3724_ _3699_/A _3724_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7492_ clb_input_west[1] clb_input[25] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_147_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_6443_ _6248_/A _6443_/B _6444_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_134_528 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_517 VGND VPWR sky130_fd_sc_hd__fill_2
X_6374_ _6123_/X _6327_/X _6373_/X _6375_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_115_753 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_508 VGND VPWR sky130_fd_sc_hd__decap_12
X_5325_ _5325_/A _5269_/X _5325_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_115_797 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_285 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_425 VGND VPWR sky130_fd_sc_hd__decap_8
X_5256_ _7287_/A _7223_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_87_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_309 VGND VPWR sky130_fd_sc_hd__decap_12
X_4207_ _4189_/X conf_hcb[10] _4207_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5187_ south_single_out[3] _5922_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4138_ _4132_/Y _4138_/B _4138_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_394 VGND VPWR sky130_fd_sc_hd__decap_3
X_4069_ _3953_/A _4069_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_84_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_39 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_762 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_795 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_615 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_812 VGND VPWR sky130_fd_sc_hd__decap_12
X_7759_ _3713_/Y _7759_/Q _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_11_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_193 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_742 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_764 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_648 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_626 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_681 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_835 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_581 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_401 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_294 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_867 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_681 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_303 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_594 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_5110_ _4309_/A _5106_/X _5107_/X _5108_/X _5109_/X _5110_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6090_ _6090_/A _4915_/B east_single_in[3] _6090_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_3_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_618 VGND VPWR sky130_fd_sc_hd__decap_8
X_5041_ _5041_/A _5041_/B _5041_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_97_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_478 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_320 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_898 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_515 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_567 VGND VPWR sky130_fd_sc_hd__decap_12
X_6992_ _6990_/A _6992_/B _6993_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5943_ _5944_/C _5944_/D _5942_/Y _5865_/X _5938_/X _5943_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_34_762 VGND VPWR sky130_fd_sc_hd__fill_1
X_5874_ _7333_/D _7269_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4825_ _7558_/Q _5981_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7613_ _7613_/D _5178_/A _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_467 VGND VPWR sky130_fd_sc_hd__decap_12
X_7544_ _7544_/D _4892_/A _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4756_ _7570_/Q _5862_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7475_ _7475_/HI north_clb_input[27] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_107_506 VGND VPWR sky130_fd_sc_hd__decap_12
X_3707_ _3718_/A conf_hcb[98] _3713_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4687_ _5627_/A _5608_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6426_ _6389_/A _6400_/B _6413_/Y _6161_/X _6422_/X _6426_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6357_ _6352_/X _6354_/Y _6355_/X _6356_/Y _6357_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_108_57 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_806 VGND VPWR sky130_fd_sc_hd__decap_12
X_5308_ _4538_/X _5266_/X _5262_/X south_double_out[3] _5308_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_130_553 VGND VPWR sky130_fd_sc_hd__fill_2
X_6288_ _6272_/C _6288_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_130_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_501 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_512 VGND VPWR sky130_fd_sc_hd__decap_8
X_5239_ _5179_/X _5238_/Y _5239_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_84_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_651 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_201 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_234 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_223 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_105 psn_inst_psn_buff_105/A psn_inst_psn_buff_105/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_267 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_256 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_245 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_434 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_743 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_289 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_620 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_278 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_645 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_850 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_353 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_876 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_194 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_345 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_740 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_784 VGND VPWR sky130_fd_sc_hd__fill_2
X_4610_ _4597_/X _5450_/B _4587_/X _4611_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XPHY_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_642 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5590_ _5539_/X _5541_/X _5576_/C _5515_/X _5553_/X _5590_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_128_163 VGND VPWR sky130_fd_sc_hd__decap_8
X_4541_ _4510_/A _4548_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_143_111 VGND VPWR sky130_fd_sc_hd__decap_8
X_7260_ _4421_/Y _7629_/Q _7241_/X _7260_/D _7260_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4472_ _4454_/X _4470_/Y _4471_/X _4472_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_144_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_144 VGND VPWR sky130_fd_sc_hd__fill_2
X_6211_ west_single_out[3] _6221_/A _6211_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_131_306 VGND VPWR sky130_fd_sc_hd__decap_8
X_7191_ _7196_/A _7189_/B _7191_/C _4411_/X _7191_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6142_ _6136_/Y _6141_/X _6116_/A _6142_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_112_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_721 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_275 VGND VPWR sky130_fd_sc_hd__decap_3
X_6073_ _6663_/A _6334_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_66_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_5024_ _5020_/Y _5023_/X _7516_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6975_ _6990_/A _6975_/B _6975_/C _4198_/Y _6976_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_54_868 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_507 VGND VPWR sky130_fd_sc_hd__decap_12
X_5926_ _4802_/A _5924_/X _5925_/X _5919_/A _5926_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_80_164 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_406 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_428 VGND VPWR sky130_fd_sc_hd__decap_6
X_5857_ _5857_/A _5857_/B _5869_/C _7192_/D _5857_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4808_ _6022_/A _5979_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_5788_ _5782_/C _5788_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4739_ _4734_/Y _4739_/B _4739_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7527_ _4972_/Y _4970_/A _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7458_ _7458_/HI north_clb_input[10] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_108_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_27 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_306 VGND VPWR sky130_fd_sc_hd__decap_3
X_6409_ _6385_/A _6422_/D _6419_/A _6146_/X _6382_/B _6409_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_107_358 VGND VPWR sky130_fd_sc_hd__decap_8
X_7389_ _7385_/X _7386_/Y _7387_/X _7388_/X _7389_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_77_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_426 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_342 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_802 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_161 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_710 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_529 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_604 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_518 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_188 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_339 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_380 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_873 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_12_0_clk clkbuf_4_6_0_clk/X _7652_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_67_437 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_256 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_70 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_651 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_27_0_clk clkbuf_5_27_0_clk/A _7637_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_62_120 VGND VPWR sky130_fd_sc_hd__decap_8
X_6760_ _6756_/X _6757_/Y _6758_/X _6759_/Y _6760_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_35_367 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_838 VGND VPWR sky130_fd_sc_hd__decap_4
X_3972_ _6480_/D _3972_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_90_495 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_197 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_581 VGND VPWR sky130_fd_sc_hd__decap_4
X_5711_ _5691_/A _4720_/A _5715_/C _5711_/D _5711_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6691_ _5102_/B _6691_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5642_ _5637_/A _5635_/B _5622_/X _5862_/D _5642_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5573_ _5581_/A _5540_/X _5576_/C _5784_/B1 _5570_/X _5573_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_117_634 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_623 VGND VPWR sky130_fd_sc_hd__fill_2
X_7312_ _7184_/A _7312_/B _7312_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4524_ _4524_/A _4523_/X _7613_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7243_ _7628_/Q _7243_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_104_306 VGND VPWR sky130_fd_sc_hd__fill_2
X_4455_ _7317_/B _7289_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_7174_ _7174_/A _7174_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4386_ _4376_/X _4385_/Y _4365_/X _4386_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6125_ _6122_/B _6125_/B _6125_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_100_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_459 VGND VPWR sky130_fd_sc_hd__decap_4
X_6056_ _5047_/A east_single_in[0] _5051_/Y _6056_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_100_589 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_481 VGND VPWR sky130_fd_sc_hd__decap_8
X_5007_ _5007_/A _5007_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_26_312 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_17 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_153 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_518 VGND VPWR sky130_fd_sc_hd__fill_1
X_6958_ _6956_/X _6957_/Y _6958_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_35_890 VGND VPWR sky130_fd_sc_hd__decap_8
X_6889_ _6889_/A _6889_/B _6889_/C _6754_/X _6889_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5909_ _5899_/A _4802_/A _5929_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_14_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_269 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_420 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_623 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_223 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_802 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_470 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_237 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_367 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_337 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_500 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_522 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_381 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_464 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_445 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_348 VGND VPWR sky130_fd_sc_hd__decap_12
X_4240_ _4090_/A _4272_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_489 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_670 VGND VPWR sky130_fd_sc_hd__decap_12
X_4171_ _6941_/B _4171_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_122_692 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_821 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_256 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_407 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_898 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_248 VGND VPWR sky130_fd_sc_hd__fill_1
X_6812_ _4106_/A _6812_/B _6812_/C _6674_/D _6812_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_23_326 VGND VPWR sky130_fd_sc_hd__decap_3
X_3955_ _3955_/A _3956_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_149_501 VGND VPWR sky130_fd_sc_hd__decap_12
X_6743_ _6739_/X _6740_/X _6741_/X _6742_/Y _6743_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6674_ _6670_/A _6684_/D _6662_/X _6674_/D _6674_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_32_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_3886_ _3886_/A conf_hcb[64] _3886_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_118_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5625_ _5627_/A _5637_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_431 VGND VPWR sky130_fd_sc_hd__decap_12
X_5556_ _5068_/Y _5848_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4507_ _4481_/X _5244_/A _4499_/X _4508_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5487_ _5487_/A _5509_/C _5485_/X _5487_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_132_434 VGND VPWR sky130_fd_sc_hd__decap_3
X_4438_ _4437_/Y _4439_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7226_ _4416_/Y _7225_/X _7226_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_132_467 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_381 VGND VPWR sky130_fd_sc_hd__decap_12
X_7157_ _7156_/Y _7155_/X _7157_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4369_ _7640_/Q _4369_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_86_532 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_201 VGND VPWR sky130_fd_sc_hd__fill_2
X_6108_ _6102_/B _5736_/A _6108_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_7088_ _7088_/A _7088_/B _7090_/A VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_58_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_226 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_204 VGND VPWR sky130_fd_sc_hd__decap_8
X_6039_ _4976_/Y _6038_/Y _6039_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_132_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_49 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_760 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_123 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_98 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_486 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_681 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_329 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_72 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_50 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_289 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_557 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_900 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_270 VGND VPWR sky130_fd_sc_hd__decap_4
X_3740_ _3740_/A _3739_/X _7753_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_32_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_526 VGND VPWR sky130_fd_sc_hd__fill_1
X_6390_ _6413_/A _6389_/X _6443_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_63_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5410_ _5405_/A _5410_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_114_401 VGND VPWR sky130_fd_sc_hd__decap_8
X_5341_ _5341_/A _5343_/A _5390_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_99_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_156 VGND VPWR sky130_fd_sc_hd__decap_4
X_7011_ _7016_/C _6994_/B _7010_/Y _6751_/X _7007_/X _7011_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5272_ _5272_/A _5272_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_141_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_489 VGND VPWR sky130_fd_sc_hd__fill_2
X_4223_ _7070_/A _7075_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_101_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_874 VGND VPWR sky130_fd_sc_hd__decap_8
X_4154_ _4133_/X _6867_/B _4153_/X _4155_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_68_565 VGND VPWR sky130_fd_sc_hd__decap_12
X_4085_ _4067_/X conf_hcb[30] _4093_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_259 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_123 VGND VPWR sky130_fd_sc_hd__decap_12
X_6726_ _6759_/A _6726_/B _6721_/A _6464_/D _6726_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XPHY_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4987_ _4974_/A conf_sb[14] _4987_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_11_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_3938_ _6381_/B _6398_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_6657_ _6657_/A _6657_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3869_ _3886_/A conf_hcb[67] _3869_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6588_ _7703_/Q _6620_/B VGND VPWR sky130_fd_sc_hd__buf_1
Xclkbuf_4_2_0_clk clkbuf_4_3_0_clk/A clkbuf_5_5_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_5608_ _5608_/A _4691_/Y _5608_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_152_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_784 VGND VPWR sky130_fd_sc_hd__decap_3
X_5539_ _5538_/X _5539_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_127_89 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_297 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_489 VGND VPWR sky130_fd_sc_hd__decap_12
X_7209_ _7209_/A _7209_/B _7209_/C _7211_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_59_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_535 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_440 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_635 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_638 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_515 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_300 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_250 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_398 VGND VPWR sky130_fd_sc_hd__fill_2
X_5890_ _5544_/X _5839_/X _5889_/X _5890_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4910_ _7540_/Q _6090_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4841_ _4819_/X _5742_/B _4836_/X _4841_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_61_785 VGND VPWR sky130_fd_sc_hd__decap_8
X_7560_ _4816_/Y _5970_/C _7558_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4772_ _5826_/B _4773_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7491_ clb_input_west[0] clb_input[24] VGND VPWR sky130_fd_sc_hd__buf_2
X_6511_ _6511_/A _6510_/X _6512_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_3723_ _5747_/C _3723_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_147_879 VGND VPWR sky130_fd_sc_hd__decap_12
X_6442_ _6441_/Y _6443_/B _6444_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_9_171 VGND VPWR sky130_fd_sc_hd__decap_12
X_6373_ _6328_/Y _6372_/X _6373_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_142_551 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_5324_ _5171_/X _5272_/X _5323_/X _5325_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_5255_ _5254_/X _5255_/B _5255_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_102_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_841 VGND VPWR sky130_fd_sc_hd__decap_12
X_4206_ _4206_/A _4206_/B _7672_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_96_682 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_362 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_716 VGND VPWR sky130_fd_sc_hd__decap_12
X_5186_ _5178_/X _5186_/A2 _5164_/X _5185_/X _5186_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_96_693 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_866 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_332 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_321 VGND VPWR sky130_fd_sc_hd__decap_4
X_4137_ _4133_/X _6889_/A _4124_/X _4138_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_28_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_4068_ _4067_/X conf_hcb[33] _4074_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_71_527 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7758_ _3717_/Y _7758_/Q _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_12_638 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_609 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7689_ _4109_/Y _4105_/A _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6709_ _7159_/A _6710_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_11_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_660 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_754 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_605 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_787 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_275 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_855 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_825 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_398 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_771 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_91 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_465 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_413 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_251 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_498 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_284 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_457 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_323 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_693 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_315 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_143_326 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_562 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_402 VGND VPWR sky130_fd_sc_hd__decap_8
X_5040_ _5021_/X _6058_/A _5035_/X _5041_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_111_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_192 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_332 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_663 VGND VPWR sky130_fd_sc_hd__decap_8
X_6991_ _7012_/A _7016_/B _6991_/C _7017_/B _7021_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_38_579 VGND VPWR sky130_fd_sc_hd__fill_1
X_5942_ _5919_/X _5942_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5873_ _5873_/A _5873_/B _5831_/X _5869_/B _5873_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4824_ _4834_/A conf_vcb[1] _4827_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7612_ _7612_/D _5164_/A _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4755_ _4744_/A conf_vcb[13] _4759_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_479 VGND VPWR sky130_fd_sc_hd__decap_8
X_7543_ _7543_/D _7543_/Q _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_3706_ _3706_/A _3718_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_119_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_518 VGND VPWR sky130_fd_sc_hd__fill_2
X_4686_ _4696_/A conf_vcb[26] _4686_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7474_ _7474_/HI north_clb_input[26] VGND VPWR sky130_fd_sc_hd__conb_1
X_6425_ _6418_/X _6421_/Y _6422_/X _6424_/Y _6425_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6356_ _3895_/X _6321_/X _6345_/C west_double_out[1] _6356_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_89_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_818 VGND VPWR sky130_fd_sc_hd__decap_12
X_5307_ _4549_/Y _4555_/X _5303_/C _5266_/X _5307_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6287_ _6282_/X _6284_/Y _6285_/X _6286_/X _6287_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_130_576 VGND VPWR sky130_fd_sc_hd__decap_4
X_5238_ _5244_/A _5244_/B _5195_/X _5068_/Y _5238_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_130_598 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_68 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_790 VGND VPWR sky130_fd_sc_hd__decap_3
X_5169_ _5169_/A _5169_/B _4497_/Y _5170_/C VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_83_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_825 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_527 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_335 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_78 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_224 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_251 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_106 psn_inst_psn_buff_106/A psn_inst_psn_buff_102/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_268 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_257 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_246 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_235 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_755 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_279 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_468 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_632 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_799 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_657 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_551 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_619 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_107 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_862 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_811 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_611 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_162 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_376 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_357 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_571 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_654 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_276 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4540_ _4540_/A _4540_/B _7610_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_337 VGND VPWR sky130_fd_sc_hd__decap_4
X_4471_ _4417_/A _4471_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6210_ _3837_/X _3843_/X _6229_/C _6210_/D _6210_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_116_359 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_348 VGND VPWR sky130_fd_sc_hd__decap_8
X_7190_ _7189_/A _4401_/Y _7182_/X _5932_/X _7162_/B _7190_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_143_178 VGND VPWR sky130_fd_sc_hd__decap_4
X_6141_ _7736_/Q _6138_/X _6140_/X _6132_/X _6141_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_98_711 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_405 VGND VPWR sky130_fd_sc_hd__decap_4
X_6072_ _6070_/A _4988_/A east_single_in[1] _6070_/X _6071_/X west_single_out[1] VGND
+ VPWR sky130_fd_sc_hd__a32o_4
XFILLER_112_598 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_287 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_490 VGND VPWR sky130_fd_sc_hd__decap_8
X_5023_ _5021_/X _6061_/A _5012_/X _5023_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_66_674 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_398 VGND VPWR sky130_fd_sc_hd__decap_4
X_6974_ _6973_/Y _6972_/X north_clb_input[3] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_80_132 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5925_ _5925_/A _5925_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_80_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_880 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_519 VGND VPWR sky130_fd_sc_hd__decap_3
X_5856_ _5862_/A _5833_/A _5856_/C _5867_/B _5856_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4807_ _4807_/A conf_vcb[4] _4807_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_21_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_788 VGND VPWR sky130_fd_sc_hd__decap_8
X_5787_ _5783_/X _5784_/Y _5785_/X _5786_/X _5787_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_107_304 VGND VPWR sky130_fd_sc_hd__fill_1
X_4738_ _4735_/X _4737_/X _4725_/X _4739_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7526_ _7526_/D _7526_/Q _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_849 VGND VPWR sky130_fd_sc_hd__decap_12
X_7457_ _7457_/HI north_clb_input[9] VGND VPWR sky130_fd_sc_hd__conb_1
X_4669_ _4651_/X conf_vcb[29] _4669_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_150_605 VGND VPWR sky130_fd_sc_hd__decap_12
X_6408_ _6385_/A _6387_/A _6402_/Y _6407_/Y _6408_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_122_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_7388_ _7383_/A _4482_/A _7370_/C _7388_/D _7388_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6339_ _6337_/Y _6338_/X _6317_/X _6339_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_131_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_659 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_276 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_298 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_287 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_641 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_471 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_600 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_346 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_187 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_900 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_63 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_101 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_123 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_115 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_90 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_392 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_395 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_663 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_825 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_3971_ _3971_/A _6480_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_62_154 VGND VPWR sky130_fd_sc_hd__decap_6
X_5710_ _5715_/C _5711_/D _5709_/Y _5499_/X _5706_/X _5710_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_148_215 VGND VPWR sky130_fd_sc_hd__decap_8
X_6690_ _6686_/X _6687_/Y _6688_/X _6689_/Y _6690_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_93_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_541 VGND VPWR sky130_fd_sc_hd__decap_8
X_5641_ _5608_/A _5637_/D _5635_/A _4682_/Y _5641_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_117_602 VGND VPWR sky130_fd_sc_hd__decap_8
X_5572_ _5567_/X _5569_/X _5570_/X _5571_/Y _5572_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_116_101 VGND VPWR sky130_fd_sc_hd__decap_3
X_7311_ _4449_/X _4456_/X _7310_/X _7247_/D _7337_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_4523_ _4513_/X _5175_/A _4499_/X _4523_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_117_646 VGND VPWR sky130_fd_sc_hd__decap_6
X_7242_ _7234_/A _7234_/B _7241_/X _7242_/D _7276_/B VGND VPWR sky130_fd_sc_hd__and4_4
X_4454_ _4376_/A _4454_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_113_852 VGND VPWR sky130_fd_sc_hd__fill_2
X_7173_ _7173_/A _7172_/X _7174_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4385_ _7637_/Q _4385_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_131_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_6124_ _6124_/A _7736_/Q _6125_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_105_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_552 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_725 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_703 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_395 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_513 VGND VPWR sky130_fd_sc_hd__decap_6
X_6055_ _6055_/A _6219_/D _6055_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_105_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5006_ _5015_/A conf_sb[10] _5009_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_39_630 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_869 VGND VPWR sky130_fd_sc_hd__decap_8
X_6957_ _6921_/A _6921_/B _6948_/Y _6691_/X _6954_/X _6957_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_54_677 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_880 VGND VPWR sky130_fd_sc_hd__decap_3
X_5908_ vertical_global[2] _5908_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6888_ _6867_/A _6883_/B _6855_/X _6879_/B _6888_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_22_530 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_5839_ _5839_/A _5839_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_883 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_154_218 VGND VPWR sky130_fd_sc_hd__decap_12
X_7509_ _7509_/D _7509_/Q _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_151_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_668 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_585 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_736 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_489 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_688 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_91 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_534 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_894 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_578 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_556 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_262 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_457 VGND VPWR sky130_fd_sc_hd__decap_8
X_4170_ _6913_/D _6941_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_122_682 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_725 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_909 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_110 VGND VPWR sky130_fd_sc_hd__decap_12
X_6811_ _4106_/Y _7688_/Q _6811_/C _6811_/D _6811_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_91_772 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_828 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_338 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_513 VGND VPWR sky130_fd_sc_hd__decap_12
X_3954_ _7714_/Q _3955_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6742_ _4070_/X _4077_/X _6730_/X _6674_/D _6742_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_3885_ _3879_/Y _3885_/B _7726_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6673_ west_single_in[1] _6674_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_31_371 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_5624_ _5615_/A _5615_/B _5622_/X _5915_/D _5658_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_133_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_5555_ _5555_/A _5571_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_476 VGND VPWR sky130_fd_sc_hd__decap_12
X_5486_ _5486_/A _5486_/B _5487_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_4506_ _5232_/C _5244_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4437_ _7627_/Q _4437_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7225_ _7628_/Q _7627_/Q _7225_/C _7225_/D _7225_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_105_638 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_619 VGND VPWR sky130_fd_sc_hd__decap_12
X_7156_ _7156_/A _7156_/B _7156_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_693 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_393 VGND VPWR sky130_fd_sc_hd__decap_4
X_4368_ _4368_/A conf_vcb[83] _4371_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6107_ _6102_/B _6105_/Y _6106_/Y _6107_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_59_736 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_181 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_4299_ _5075_/C _5072_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_7087_ _7078_/B _6837_/X _7074_/A _7045_/X _7088_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_59_758 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_257 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_599 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_611 VGND VPWR sky130_fd_sc_hd__decap_12
X_6038_ _6351_/D _6038_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_132_68 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_238 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_493 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_79 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_666 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_349 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_135 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_88 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_371 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_11_0_clk clkbuf_4_5_0_clk/X _7574_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XPHY_99 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_548 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_98 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_26_0_clk clkbuf_5_27_0_clk/A _7558_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_151_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_435 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_265 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_118 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_257 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_577 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_611 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_290 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_772 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_912 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_794 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_282 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_72 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_455 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_647 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_658 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_571 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5340_ _5348_/A _5348_/B _5340_/C _5343_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_141_221 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_424 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_581 VGND VPWR sky130_fd_sc_hd__decap_8
X_5271_ _5269_/B _5287_/A _5272_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_142_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_457 VGND VPWR sky130_fd_sc_hd__fill_1
X_7010_ _7010_/A _7010_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4222_ _4222_/A _7070_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_101_129 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_330 VGND VPWR sky130_fd_sc_hd__decap_4
X_4153_ _4091_/A _4153_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4084_ _4081_/Y _4084_/B _4084_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_96_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_577 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_536 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_249 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_761 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_485 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_4986_ _4986_/A _4986_/B _7524_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6725_ _6724_/X _6725_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3937_ _3919_/X conf_hcb[55] _3937_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_466 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_516 VGND VPWR sky130_fd_sc_hd__decap_8
X_6656_ _6656_/A _6657_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3868_ _3862_/Y _3868_/B _3868_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6587_ _6619_/C _6587_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_730 VGND VPWR sky130_fd_sc_hd__fill_2
X_3799_ _3779_/X _6114_/A _3794_/X _3800_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5607_ _5607_/A _5607_/B _5670_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_5538_ _5571_/A _5538_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_210 VGND VPWR sky130_fd_sc_hd__decap_4
X_7208_ _7208_/A _7208_/B _7209_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_87_39 VGND VPWR sky130_fd_sc_hd__decap_4
X_5469_ _5466_/X _5468_/X _5469_/C _5470_/B VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_120_416 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_405 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_319 VGND VPWR sky130_fd_sc_hd__decap_3
X_7139_ _7104_/X _4261_/X _7132_/C east_double_in[0] _7136_/X _7139_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_98_190 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_544 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_685 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_794 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_783 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_474 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_764 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_797 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_190 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_254 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_287 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_105 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_864 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_801 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_300 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_525 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_901 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_750 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_772 VGND VPWR sky130_fd_sc_hd__fill_1
X_4840_ _7555_/Q _5742_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_61_731 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_105 VGND VPWR sky130_fd_sc_hd__decap_12
X_6510_ _6480_/C _3972_/X _6510_/C _6456_/X _6510_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4771_ _4771_/A conf_vcb[10] _4776_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7490_ clb_input_south[7] clb_input[23] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_146_302 VGND VPWR sky130_fd_sc_hd__decap_12
X_3722_ _3718_/A conf_hcb[95] _3722_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_335 VGND VPWR sky130_fd_sc_hd__fill_1
X_6441_ _6123_/X _6394_/A _6440_/X _6441_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_6372_ _6370_/Y _6372_/B _6372_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_127_571 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_733 VGND VPWR sky130_fd_sc_hd__fill_1
X_5323_ _5273_/Y _5323_/B _5323_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_130_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_276 VGND VPWR sky130_fd_sc_hd__decap_6
X_5254_ _5253_/Y _5251_/X _5254_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_87_149 VGND VPWR sky130_fd_sc_hd__decap_8
X_4205_ _4191_/X _7016_/A _4182_/X _4206_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_69_853 VGND VPWR sky130_fd_sc_hd__fill_1
X_5185_ _4520_/Y _5184_/X _5185_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_96_661 VGND VPWR sky130_fd_sc_hd__decap_3
X_4136_ _6884_/A _6889_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_29_728 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_4067_ _3950_/A _4067_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_113_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_878 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_915 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7757_ _3721_/Y _7757_/Q _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4969_ _4960_/A conf_sb[18] _4969_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_302 VGND VPWR sky130_fd_sc_hd__decap_3
X_6708_ _6707_/X _6708_/B _6711_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_7688_ _7688_/D _7688_/Q _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XPHY_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_346 VGND VPWR sky130_fd_sc_hd__decap_12
X_6639_ _6184_/A _6591_/X _6640_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_672 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_806 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_593 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_799 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_108 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_672 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_171 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_525 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_536 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_580 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_572 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_425 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_335 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_703 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_447 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_108 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_661 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_503 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_631 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_355 VGND VPWR sky130_fd_sc_hd__decap_8
X_6990_ _6990_/A _7012_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xclkbuf_4_1_0_clk clkbuf_4_0_0_clk/A clkbuf_5_3_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_19_750 VGND VPWR sky130_fd_sc_hd__decap_3
X_5941_ _5936_/X _5937_/Y _5938_/X _5940_/X _5941_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_19_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_5872_ _5831_/X _5867_/D _5862_/C _5871_/X _5867_/X _5872_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_61_550 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_403 VGND VPWR sky130_fd_sc_hd__fill_2
X_4823_ _4823_/A _4823_/B _4823_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7611_ _4535_/Y _7611_/Q _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_611 VGND VPWR sky130_fd_sc_hd__decap_12
X_4754_ _4750_/Y _4754_/B _7571_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7542_ _4902_/Y _7542_/Q _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_3705_ _3705_/A _3704_/X _3705_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7473_ _7473_/HI north_clb_input[25] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_135_806 VGND VPWR sky130_fd_sc_hd__decap_12
X_4685_ _4685_/A _4685_/B _4685_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_176 VGND VPWR sky130_fd_sc_hd__decap_3
X_6424_ _6400_/A _6424_/B _6419_/A _6558_/D _6424_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6355_ _6330_/X _6343_/D _6355_/C _6345_/B _6355_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6286_ _6286_/A _6260_/A _6283_/Y _6351_/D _6286_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5306_ _5303_/C _4545_/X _5299_/C south_double_out[2] _5303_/X _5306_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_130_533 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_224 VGND VPWR sky130_fd_sc_hd__decap_12
X_5237_ _5169_/A _5169_/B _5227_/Y north_double_out[2] _5234_/X _5237_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_69_672 VGND VPWR sky130_fd_sc_hd__decap_3
X_5168_ _7614_/Q _5169_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_4119_ _4116_/Y _4119_/B _4119_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5099_ _7760_/Q _5095_/X _5096_/X _5097_/X _5098_/X _5099_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_56_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_344 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_506 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_152 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_848 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_837 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_377 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_366 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_347 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_225 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VPWR sky130_fd_sc_hd__decap_3
Xpsn_inst_psn_buff_107 psn_inst_psn_buff_110/X psn_inst_psn_buff_103/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_52_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_712 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_258 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_247 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_236 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_269 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_669 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_308 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_563 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_403 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_436 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_333 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_506 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_528 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_678 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_148_419 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_288 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_666 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_806 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_440 VGND VPWR sky130_fd_sc_hd__decap_12
X_4470_ _7621_/Q _4470_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_109_390 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_92 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_81 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_511 VGND VPWR sky130_fd_sc_hd__decap_8
X_6140_ _6139_/Y _6140_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_533 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_886 VGND VPWR sky130_fd_sc_hd__decap_12
X_6071_ _7524_/Q north_single_in[0] _4988_/Y _6071_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_97_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_428 VGND VPWR sky130_fd_sc_hd__decap_8
X_5022_ _7516_/Q _6061_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_66_642 VGND VPWR sky130_fd_sc_hd__decap_8
X_6973_ _6710_/A _6972_/B _6973_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_53_336 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_144 VGND VPWR sky130_fd_sc_hd__decap_8
X_5924_ _5924_/A _5924_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_53_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_5855_ _5857_/A _5857_/B _5869_/C _5568_/X _5827_/B _5855_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_22_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_4806_ _4806_/A _4805_/X _7562_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_121 VGND VPWR sky130_fd_sc_hd__fill_1
X_5786_ _4729_/Y _4736_/A _5767_/C _5862_/D _5786_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4737_ _5750_/D _4737_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7525_ _4982_/Y _7525_/Q _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_135_614 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_102 VGND VPWR sky130_fd_sc_hd__decap_8
X_7456_ _7456_/HI north_clb_input[8] VGND VPWR sky130_fd_sc_hd__conb_1
X_4668_ _4668_/A _4668_/B _4668_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6407_ _6606_/A1 _6404_/Y _6406_/Y _6407_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_150_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_712 VGND VPWR sky130_fd_sc_hd__decap_8
X_7387_ _7364_/A _4492_/X _7357_/X _7353_/D _7387_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4599_ _5427_/B _5417_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6338_ _6315_/B _6138_/X _6140_/X _6332_/X _6338_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_131_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_533 VGND VPWR sky130_fd_sc_hd__decap_12
X_6269_ _6269_/A _6269_/B _6261_/A _6261_/B _6299_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_95_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_609 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_23 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_612 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_369 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_199 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_380 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_410 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_105 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_476 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_211 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_277 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_94 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_623 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_100 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_3970_ _6448_/B _3971_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_86_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5640_ _4676_/X _5613_/X _5622_/X _5784_/B1 _5637_/X _5640_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5571_ _5571_/A _4655_/Y _5571_/C _5571_/D _5571_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_129_474 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_463 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_113 VGND VPWR sky130_fd_sc_hd__decap_8
X_7310_ _7310_/A _7310_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4522_ _4522_/A _5175_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_144_444 VGND VPWR sky130_fd_sc_hd__decap_12
X_7241_ _7240_/Y _7241_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4453_ _4463_/A conf_vcb[67] _4453_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_7_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_477 VGND VPWR sky130_fd_sc_hd__decap_8
X_7172_ _7163_/A _4410_/A _7172_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_113_820 VGND VPWR sky130_fd_sc_hd__decap_12
X_4384_ _4384_/A conf_vcb[80] _4387_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_98_520 VGND VPWR sky130_fd_sc_hd__decap_12
X_6123_ horizontal_global[2] _6123_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_330 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_564 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_6054_ _6053_/X _6219_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_58_417 VGND VPWR sky130_fd_sc_hd__decap_12
X_5005_ _5002_/Y _5005_/B _7520_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_82_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_6956_ _6952_/X _6953_/Y _6954_/X _6955_/Y _6956_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_54_667 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_306 VGND VPWR sky130_fd_sc_hd__decap_4
X_5907_ _5900_/X _5910_/A _5965_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_22_520 VGND VPWR sky130_fd_sc_hd__fill_1
X_6887_ _6855_/X _4142_/X _6886_/Y _6751_/X _6883_/X _6887_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_22_542 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_851 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_715 VGND VPWR sky130_fd_sc_hd__decap_12
X_5838_ _5836_/B _5837_/X _5839_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_50_895 VGND VPWR sky130_fd_sc_hd__decap_8
X_5769_ _5805_/A _5805_/B _5759_/A _5759_/B _5769_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7508_ east_double_in[1] west_double_out[3] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_147_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_7439_ _7439_/HI east_clb_input[15] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_146_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_639 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_820 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_853 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_597 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_428 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_439 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_910 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_807 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_546 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_260 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_296 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_414 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_650 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_801 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_171 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_501 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_645 VGND VPWR sky130_fd_sc_hd__decap_8
X_6810_ _4106_/A _6812_/B _6812_/C _6809_/X _6780_/B _6810_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_36_656 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_784 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_626 VGND VPWR sky130_fd_sc_hd__decap_8
X_3953_ _3953_/A _3953_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6741_ _4072_/A _4076_/A _6769_/A _4087_/X _6741_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_149_525 VGND VPWR sky130_fd_sc_hd__decap_12
X_3884_ _3863_/X _6269_/B _3883_/X _3885_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6672_ _6672_/A _7698_/Q _6700_/A _4058_/X _6672_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5623_ _5987_/A _5915_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_720 VGND VPWR sky130_fd_sc_hd__decap_12
X_5554_ _7588_/Q _4664_/Y _5555_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_144_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_628 VGND VPWR sky130_fd_sc_hd__fill_1
X_5485_ _7593_/Q _5495_/B _5484_/X _5485_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4505_ _5229_/C _5232_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_4436_ _4436_/A conf_vcb[70] _4441_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_7224_ _7223_/Y _7224_/B clb_input[15] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_6_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_7155_ _7155_/A _7156_/B _7155_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4367_ _4362_/Y _4366_/X _7641_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_683 VGND VPWR sky130_fd_sc_hd__fill_1
X_6106_ _6102_/A _6102_/B north_clb_output[1] _7743_/Q _6109_/A _6106_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_59_748 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_4298_ _4285_/A conf_vcb[98] _4301_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_86_567 VGND VPWR sky130_fd_sc_hd__decap_12
X_7086_ _7086_/A _7086_/B _7086_/C _7088_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_6037_ _6416_/A _6351_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_82_740 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_818 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6939_ _6938_/A _6941_/B _6941_/C _6809_/X _6914_/B _6939_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_147 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_89 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_523 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_455 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_733 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_288 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_501 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_556 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_504 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_409 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_269 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_464 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_475 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_294 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_583 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_274 VGND VPWR sky130_fd_sc_hd__fill_1
X_5270_ _4549_/Y _7607_/Q _5287_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_102_609 VGND VPWR sky130_fd_sc_hd__decap_12
X_4221_ _4221_/A _4222_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_49_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_832 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_523 VGND VPWR sky130_fd_sc_hd__decap_12
X_4152_ _6883_/B _6867_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_545 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_686 VGND VPWR sky130_fd_sc_hd__decap_12
X_4083_ _4069_/X _6722_/A _4060_/X _4084_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_96_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_420 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_497 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_147 VGND VPWR sky130_fd_sc_hd__decap_12
X_4985_ _4975_/X _6070_/A _4966_/X _4986_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6724_ _6723_/X _6724_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_3936_ _3933_/Y _3936_/B _7717_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_489 VGND VPWR sky130_fd_sc_hd__decap_6
X_6655_ _6655_/A _6655_/B _6656_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_3867_ _3863_/X _6272_/A _3854_/X _3868_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6586_ _4012_/X _6619_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_3798_ _6173_/A _6114_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5606_ _5627_/A _4691_/A _4675_/A _4682_/Y _5607_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_145_550 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_764 VGND VPWR sky130_fd_sc_hd__decap_12
X_5537_ _5533_/C _5571_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_274 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_425 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_222 VGND VPWR sky130_fd_sc_hd__decap_12
X_7207_ _7167_/X _7169_/X _7198_/Y _5877_/X _7204_/X _7208_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5468_ _5503_/B _5468_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4419_ _4419_/A _4419_/B _4419_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_99_670 VGND VPWR sky130_fd_sc_hd__fill_1
X_5399_ _5395_/C _5423_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_113_480 VGND VPWR sky130_fd_sc_hd__decap_8
X_7138_ _7133_/X _7135_/Y _7136_/X _7137_/Y _7138_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_86_320 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_653 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_876 VGND VPWR sky130_fd_sc_hd__decap_12
X_7069_ _7069_/A _7074_/B _7041_/X _4229_/A _7069_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_86_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_445 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_489 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_528 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_731 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_753 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_296 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_266 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_574 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_128 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_832 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_62 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_876 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_353 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_342 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_910 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_507 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_559 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_489 VGND VPWR sky130_fd_sc_hd__decap_4
X_4770_ _4767_/Y _4770_/B _4770_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_517 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_506 VGND VPWR sky130_fd_sc_hd__decap_8
X_3721_ _3721_/A _3720_/X _3721_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6440_ _6394_/Y _6439_/X _6440_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__decap_12
X_6371_ _6330_/X _6359_/B _6243_/C _6324_/B _6372_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_114_211 VGND VPWR sky130_fd_sc_hd__decap_3
X_5322_ _5320_/Y _5321_/X _5323_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_115_767 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_244 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_607 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_618 VGND VPWR sky130_fd_sc_hd__decap_8
X_5253_ _7220_/A _5253_/B _5253_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4204_ _6990_/A _7016_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5184_ _5924_/A _5184_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_110_450 VGND VPWR sky130_fd_sc_hd__decap_8
X_4135_ _6855_/A _6884_/A VGND VPWR sky130_fd_sc_hd__inv_8
Xclkbuf_5_10_0_clk clkbuf_4_5_0_clk/X _7579_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_113_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_4066_ _4066_/A _4066_/B _7695_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_83_367 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_5_25_0_clk clkbuf_5_25_0_clk/A _7726_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_64_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_754 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_220 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7756_ _3726_/Y _5747_/C _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4968_ _4964_/Y _4968_/B _4968_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_6707_ _6706_/Y _6707_/B _6707_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_3919_ _3832_/A _3919_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7687_ _4119_/Y _6779_/A _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_4899_ _4889_/X conf_sb[33] _4899_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6638_ _6637_/Y _6591_/X _6640_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_153_829 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_818 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_68 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_6569_ _7710_/Q _6534_/Y _6569_/C _6571_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_145_391 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_726 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_331 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_835 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_194 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_890 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_754 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_765 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_776 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_640 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_622 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_666 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_594 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_586 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_737 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_673 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_802 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_515 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_643 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_838 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_816 VGND VPWR sky130_fd_sc_hd__decap_8
X_5940_ _4784_/Y _5931_/B _5914_/X _7260_/D _5940_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_65_389 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_367 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_337 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_220 VGND VPWR sky130_fd_sc_hd__decap_12
X_5871_ _5104_/X _5871_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7610_ _7610_/D _7610_/Q _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_22_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_4822_ _4819_/X _5993_/B _4809_/X _4823_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_21_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_303 VGND VPWR sky130_fd_sc_hd__fill_2
X_4753_ _4735_/X _5827_/A _4752_/X _4754_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7541_ _4908_/Y _4904_/A _7545_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_147_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_111 VGND VPWR sky130_fd_sc_hd__decap_8
X_3704_ _4958_/A _3703_/Y _3699_/X _3704_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7472_ _7472_/HI north_clb_input[24] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_135_818 VGND VPWR sky130_fd_sc_hd__decap_12
X_6423_ _6423_/A _6558_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4684_ _4681_/X _4683_/X _4671_/X _4685_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6354_ _6355_/C _3901_/X _6353_/Y west_double_out[0] _6350_/X _6354_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_142_361 VGND VPWR sky130_fd_sc_hd__decap_12
X_6285_ _6294_/A _3882_/A _6258_/A _6290_/D _6285_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_89_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_5305_ _5300_/X _5302_/Y _5303_/X _5304_/Y _5305_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_130_545 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_459 VGND VPWR sky130_fd_sc_hd__fill_1
X_5236_ _5231_/X _5233_/Y _5234_/X _5235_/Y _5236_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_84_610 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_846 VGND VPWR sky130_fd_sc_hd__decap_8
X_5167_ _5229_/C _5169_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4118_ _4104_/X _4117_/Y _4091_/X _4119_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5098_ _7759_/Q west_double_in[0] _3703_/Y _5098_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_29_559 VGND VPWR sky130_fd_sc_hd__decap_12
X_4049_ _6684_/D _6658_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_72_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_518 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_215 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_359 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_776 VGND VPWR sky130_fd_sc_hd__decap_12
Xpsn_inst_psn_buff_108 _5294_/Y psn_inst_psn_buff_105/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_259 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_248 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_237 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_226 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_724 VGND VPWR sky130_fd_sc_hd__fill_2
X_7739_ _7739_/D _7739_/Q _7734_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_138_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_306 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_361 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_575 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_831 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_407 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_131 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_337 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_732 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_776 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_702 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_381 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_370 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_724 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_768 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_84 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_212 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_6070_ _6070_/A south_single_in[1] _6070_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_140_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_5021_ _4925_/X _5021_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_462 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_529 VGND VPWR sky130_fd_sc_hd__decap_8
X_6972_ _6972_/A _6972_/B _6972_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_54_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_348 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_679 VGND VPWR sky130_fd_sc_hd__decap_8
X_5923_ _7184_/A _5914_/A _5923_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_34_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_381 VGND VPWR sky130_fd_sc_hd__decap_12
X_5854_ _5857_/A _5833_/A _5849_/X _5853_/X _5854_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_148_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_4805_ _4792_/X _4804_/X _4780_/X _4805_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_21_245 VGND VPWR sky130_fd_sc_hd__decap_12
X_5785_ _4741_/Y _4746_/X _5754_/X _5750_/D _5785_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7524_ _7524_/D _7524_/Q _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_144 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_807 VGND VPWR sky130_fd_sc_hd__decap_12
X_4736_ _4736_/A _5750_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_7455_ _7455_/HI east_clb_input[31] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_135_626 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_155 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_306 VGND VPWR sky130_fd_sc_hd__decap_6
X_4667_ _4654_/X _4666_/X _4642_/X _4668_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6406_ _6404_/Y _6405_/X _6384_/A _6406_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_7386_ _7397_/A _7396_/D _7370_/C _7322_/B1 _7383_/X _7386_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_150_629 VGND VPWR sky130_fd_sc_hd__decap_12
X_6337_ _6325_/X _6337_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_134_169 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_501 VGND VPWR sky130_fd_sc_hd__decap_6
X_4598_ _5423_/B _5427_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_88_223 VGND VPWR sky130_fd_sc_hd__decap_3
X_6268_ _6270_/A _6269_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_103_545 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_768 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149 VGND VPWR sky130_fd_sc_hd__decap_6
X_6199_ _6196_/X _6198_/X _6192_/A _6202_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_97_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_470 VGND VPWR sky130_fd_sc_hd__decap_12
X_5219_ _5216_/A south_single_in[3] _4336_/Y _5219_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_28_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_35 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_367 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_304 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_827 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_145 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_871 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_562 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_392 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_790 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_486 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_422 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_0_0_clk clkbuf_4_0_0_clk/A clkbuf_5_1_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_153_467 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_309 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_41 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_320 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_361 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_716 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_245 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_683 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_621 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_632 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_838 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_551 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_893 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_307 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_595 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_565 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_431 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5570_ _5576_/A _7589_/Q _5552_/X _5574_/B _5570_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_144_412 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_486 VGND VPWR sky130_fd_sc_hd__fill_2
X_4521_ _4520_/Y _4522_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7240_ _7228_/X _7240_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4452_ _4425_/A _4463_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_7_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_456 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_832 VGND VPWR sky130_fd_sc_hd__decap_12
X_7171_ _7164_/X _7173_/A _7171_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4383_ _4383_/A _4383_/B _7638_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_98_532 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_180 VGND VPWR sky130_fd_sc_hd__decap_8
X_6122_ _6122_/A _6122_/B _6185_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_6053_ west_single_in[1] _6053_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_364 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_598 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_576 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_429 VGND VPWR sky130_fd_sc_hd__decap_6
X_5004_ _4998_/X _6067_/A _4989_/X _5005_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_93_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_270 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_6955_ _6927_/A _6921_/B _6922_/A _6828_/D _6955_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5906_ _5906_/A _5906_/B _5898_/A _5910_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_6886_ _6889_/C _6886_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_10_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_5837_ _5873_/A _5826_/B _5837_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_50_863 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_5768_ _4741_/A _5805_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7507_ east_double_in[0] west_double_out[2] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_5_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_4719_ _5674_/B _4720_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7438_ _7438_/HI east_clb_input[14] VGND VPWR sky130_fd_sc_hd__conb_1
X_5699_ _5699_/A _5716_/C _5697_/X _5700_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_151_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_629 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_510 VGND VPWR sky130_fd_sc_hd__fill_2
X_7369_ _7376_/B _7370_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_1_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_865 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_161 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_386 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_760 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_819 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_587 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_437 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_813 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_535 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_248 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_440 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_668 VGND VPWR sky130_fd_sc_hd__decap_12
X_6740_ _4070_/X _4077_/X _6730_/X _6478_/X _6713_/B _6740_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_63_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_318 VGND VPWR sky130_fd_sc_hd__decap_8
X_3952_ _3804_/A _3953_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_3883_ _3854_/A _3883_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6671_ _6670_/A _6684_/D _6662_/X _6478_/X _6645_/B _6671_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_31_362 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_874 VGND VPWR sky130_fd_sc_hd__decap_8
X_5622_ _5622_/A _5622_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_136_209 VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_7_0_clk clkbuf_3_7_0_clk/A clkbuf_3_7_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_5553_ _5552_/X _4666_/X _5539_/X _5541_/X _5553_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4504_ _4503_/X _5229_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_607 VGND VPWR sky130_fd_sc_hd__decap_3
X_5484_ _7592_/Q _5184_/X _5190_/X _5481_/A _5484_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_132_426 VGND VPWR sky130_fd_sc_hd__decap_8
X_4435_ _4435_/A _4435_/B _4435_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_117_489 VGND VPWR sky130_fd_sc_hd__decap_12
X_7223_ _7223_/A _7162_/X _7223_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_132_459 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_651 VGND VPWR sky130_fd_sc_hd__decap_4
X_7154_ horizontal_global[2] _7111_/X _7153_/X _7155_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4366_ _4350_/X _4363_/Y _4365_/X _4366_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_140_470 VGND VPWR sky130_fd_sc_hd__fill_1
X_6105_ _5294_/Y _7532_/Q _6103_/A _6103_/X _6104_/X _6105_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_4297_ _4293_/Y _4297_/B _7656_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7085_ _7085_/A _7085_/B _7086_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_132_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_579 VGND VPWR sky130_fd_sc_hd__fill_1
X_6036_ _6036_/A _6416_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_27_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_281 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_432 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_178 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6938_ _6938_/A _6938_/B _6938_/C _6938_/D _6938_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_81_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_284 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6869_ _6868_/X _6889_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_10_502 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_159 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_535 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_209 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_401 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_546 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_148_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_481 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_161 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_549 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_793 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_540 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_550 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_201 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_245 VGND VPWR sky130_fd_sc_hd__decap_12
X_4220_ _4104_/A _4220_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_122_481 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_621 VGND VPWR sky130_fd_sc_hd__decap_3
X_4151_ _4151_/A _6883_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_535 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_654 VGND VPWR sky130_fd_sc_hd__decap_8
X_4082_ _4082_/A _6722_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_95_376 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_343 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_708 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_760 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_698 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_771 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_432 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_582 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_262 VGND VPWR sky130_fd_sc_hd__decap_8
X_4984_ _7524_/Q _6070_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_3935_ _3921_/X _6427_/A _3912_/X _3936_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6723_ _6769_/D _6723_/B _6723_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_23_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_6654_ _6654_/A _6654_/B _6655_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_149_367 VGND VPWR sky130_fd_sc_hd__decap_12
X_3866_ _6286_/A _6272_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5605_ _5604_/Y _5603_/X east_clb_input[6] VGND VPWR sky130_fd_sc_hd__nor2_4
X_6585_ _6585_/A _6602_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_743 VGND VPWR sky130_fd_sc_hd__decap_3
X_3797_ _3787_/A conf_hcb[79] _3797_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_11_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_776 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_242 VGND VPWR sky130_fd_sc_hd__fill_2
X_5536_ _5536_/A _5536_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_11_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5467_ _7594_/Q _5503_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_4418_ _4400_/X _4416_/Y _4417_/X _4419_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7206_ _7202_/X _7203_/Y _7204_/X _7205_/Y _7208_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_87_822 VGND VPWR sky130_fd_sc_hd__fill_2
X_5398_ _5398_/A _5405_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7137_ _4255_/X _7132_/B _7127_/C _6423_/A _7137_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_101_632 VGND VPWR sky130_fd_sc_hd__decap_8
X_4349_ _4368_/A conf_vcb[87] _4353_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_87_833 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_332 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_665 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_888 VGND VPWR sky130_fd_sc_hd__decap_12
X_7068_ _7070_/A _7075_/B _7067_/Y _6348_/A _7064_/X _7068_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_47_719 VGND VPWR sky130_fd_sc_hd__decap_12
X_6019_ _6019_/A _5993_/Y _6018_/X _6019_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_86_398 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_376 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_56 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_744 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_295 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_457 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_44 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_490 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_551 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_242 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_212 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_822 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_844 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_590 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_421 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_73 VGND VPWR sky130_fd_sc_hd__decap_3
X_3720_ _3710_/X _5739_/A _3699_/X _3720_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_60_276 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_529 VGND VPWR sky130_fd_sc_hd__decap_4
X_6370_ _6370_/A _6369_/X _6370_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_127_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_5321_ _5279_/X _4555_/X _5247_/C _5269_/B _5321_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_5_391 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_727 VGND VPWR sky130_fd_sc_hd__decap_12
X_5252_ _7284_/A _7220_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_4203_ _4189_/X conf_hcb[11] _4206_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5183_ south_single_out[0] _5924_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4134_ _7684_/Q _6855_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_84_825 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_302 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_516 VGND VPWR sky130_fd_sc_hd__decap_3
X_4065_ _4040_/X _4064_/Y _4060_/X _4066_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_113_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_519 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_903 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_251 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_593 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_295 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7755_ _7755_/D _3728_/A _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4967_ _4949_/X _4965_/Y _4966_/X _4968_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XPHY_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_287 VGND VPWR sky130_fd_sc_hd__decap_12
X_3918_ _3915_/Y _3918_/B _7720_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6706_ _6706_/A _6704_/B _6706_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7686_ _4126_/Y _7686_/Q _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_32_490 VGND VPWR sky130_fd_sc_hd__decap_8
X_4898_ _4898_/A _4898_/B _7543_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_149_175 VGND VPWR sky130_fd_sc_hd__decap_8
X_3849_ _3849_/A _3848_/X _3849_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_138_849 VGND VPWR sky130_fd_sc_hd__decap_12
X_6637_ _6458_/X _6594_/X _6636_/X _6637_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_6568_ _6568_/A _6568_/B _6569_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_3_306 VGND VPWR sky130_fd_sc_hd__decap_12
X_5519_ _4636_/X _5318_/X _5478_/X _5470_/B _5519_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_6499_ _6453_/X _6455_/X _6488_/Y _6362_/X _6495_/X _6500_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_120_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_129 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_321 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_803 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_473 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_376 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_379 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_733 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_65 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_276 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_788 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_27 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_337 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_652 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_351 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_749 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_361 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_760 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_527 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_549 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_316 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_519 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_251 VGND VPWR sky130_fd_sc_hd__decap_12
X_5870_ _5863_/X _5866_/Y _5867_/X _5869_/Y _5870_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4821_ _4821_/A _5993_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_33_232 VGND VPWR sky130_fd_sc_hd__decap_12
X_7540_ _7540_/D _7540_/Q _7539_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4752_ _4725_/A _4752_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_315 VGND VPWR sky130_fd_sc_hd__decap_8
X_3703_ _7760_/Q _3703_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7471_ _7471_/HI north_clb_input[23] VGND VPWR sky130_fd_sc_hd__conb_1
X_4683_ _4682_/Y _4683_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6422_ _6438_/A _6422_/B _6386_/A _6422_/D _6422_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_143_830 VGND VPWR sky130_fd_sc_hd__decap_12
X_6353_ _6345_/C _6353_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_115_532 VGND VPWR sky130_fd_sc_hd__decap_12
X_6284_ _6286_/A _6260_/A _6283_/Y _6046_/X _6280_/X _6284_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5304_ _4538_/X _5266_/X _5282_/X south_double_out[1] _5304_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_142_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_630 VGND VPWR sky130_fd_sc_hd__decap_12
X_5235_ south_double_out[3] _5232_/X _5235_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_111_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_760 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_622 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_600 VGND VPWR sky130_fd_sc_hd__fill_1
X_5166_ _4497_/Y _5166_/B _5255_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4117_ _6779_/A _4117_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_84_633 VGND VPWR sky130_fd_sc_hd__decap_8
X_5097_ _5096_/A _5736_/A _5097_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_83_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4048_ _6644_/D _6684_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_84_699 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_216 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_850 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_552 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_541 VGND VPWR sky130_fd_sc_hd__fill_2
Xpsn_inst_psn_buff_109 _5212_/X psn_inst_psn_buff_106/A VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_249 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_238 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_227 VGND VPWR sky130_fd_sc_hd__decap_3
X_5999_ _5975_/A _6001_/B _5999_/C _5999_/D _5999_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_24_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_788 VGND VPWR sky130_fd_sc_hd__decap_4
X_7738_ _3816_/Y _3812_/A _7726_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_137_145 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_134 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_123 VGND VPWR sky130_fd_sc_hd__decap_4
X_7669_ _7669_/D _4221_/A _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_146_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_419 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_825 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_270 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_644 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_184 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_82 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_699 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_530 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_202 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_41 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_393 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_910 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_605 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_703 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_24_0_clk clkbuf_5_25_0_clk/A _7553_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_97_224 VGND VPWR sky130_fd_sc_hd__decap_3
X_5020_ _5033_/A conf_sb[7] _5020_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_85_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_335 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_474 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_165 VGND VPWR sky130_fd_sc_hd__decap_12
X_6971_ _6970_/Y _6971_/B _6972_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_80_102 VGND VPWR sky130_fd_sc_hd__decap_8
X_5922_ _5922_/A _7184_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_0_94 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_5853_ _5852_/X _5875_/C _5851_/X _5853_/X VGND VPWR sky130_fd_sc_hd__and3_4
X_4804_ _4803_/X _4804_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_61_393 VGND VPWR sky130_fd_sc_hd__fill_2
X_5784_ _4730_/X _5794_/D _5767_/C _5784_/B1 _5780_/X _5784_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_119_101 VGND VPWR sky130_fd_sc_hd__decap_12
X_4735_ _4735_/A _4735_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_21_257 VGND VPWR sky130_fd_sc_hd__decap_12
X_7523_ _4991_/Y _4988_/A _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_119_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_7454_ _7454_/HI east_clb_input[30] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_119_167 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_819 VGND VPWR sky130_fd_sc_hd__decap_4
X_4666_ _5574_/B _4666_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_498 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_638 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_690 VGND VPWR sky130_fd_sc_hd__decap_12
X_6405_ _6381_/B _6138_/X _6140_/X _6399_/A _6405_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_7385_ _7381_/X _7382_/X _7383_/X _7384_/Y _7385_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_4597_ _4512_/X _4597_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6336_ _6336_/A _6336_/B _6336_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_115_351 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_384 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_736 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_354 VGND VPWR sky130_fd_sc_hd__decap_12
X_6267_ _6272_/A _6272_/B _6283_/A _6329_/D _6267_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6198_ _6224_/B _6198_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5218_ _5218_/A east_clb_output[0] _5218_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_398 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_482 VGND VPWR sky130_fd_sc_hd__decap_6
X_5149_ _5149_/A _5148_/Y _5149_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_151_47 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_647 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_658 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_157 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_530 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_179 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_585 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_413 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_479 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_71 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_852 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_387 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_728 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_695 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_452 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_647 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_880 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_455 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_809 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_585 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_511 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_371 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_382 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_443 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_751 VGND VPWR sky130_fd_sc_hd__decap_12
X_4520_ _5178_/A _4520_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_144_424 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_498 VGND VPWR sky130_fd_sc_hd__decap_12
X_4451_ _4451_/A _4450_/X _7625_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7170_ _7167_/X _7169_/X _7162_/A _7173_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_6121_ _6131_/C _6131_/D _6114_/A _6122_/B VGND VPWR sky130_fd_sc_hd__or3_4
X_4382_ _4376_/X _5155_/A _4365_/X _4383_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_113_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_844 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_376 VGND VPWR sky130_fd_sc_hd__decap_8
X_6052_ _7536_/Q _6050_/A north_single_in[2] _6050_/X _6051_/X east_single_out[2]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_39_611 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_387 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_5003_ _5003_/A _6067_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_39_644 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_282 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_6954_ _6915_/A _6965_/B _6917_/X _6946_/B _6954_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_53_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_5905_ _5948_/D _5906_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6885_ _6880_/X _6882_/Y _6883_/X _6884_/X _6885_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_511 VGND VPWR sky130_fd_sc_hd__decap_8
X_5836_ _5875_/C _5836_/B _5836_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_50_875 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_739 VGND VPWR sky130_fd_sc_hd__decap_12
X_5767_ _5759_/A _5759_/B _5767_/C _5915_/D _5767_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_7506_ clb_cout north_clb_cin VGND VPWR sky130_fd_sc_hd__buf_2
X_4718_ _7577_/Q _5674_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_5698_ _5684_/B _5698_/B _5699_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_7437_ _7437_/HI east_clb_input[13] VGND VPWR sky130_fd_sc_hd__conb_1
X_4649_ _4645_/Y _4649_/B _4649_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_123_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_693 VGND VPWR sky130_fd_sc_hd__decap_8
X_7368_ _7363_/A _7376_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_1_415 VGND VPWR sky130_fd_sc_hd__fill_1
X_6319_ _6345_/A _6355_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_7299_ _7299_/A _7299_/B _7347_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_104_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_408 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_173 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_850 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_647 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_628 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_883 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_363 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_210 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_424 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_547 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_809 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_3951_ _3959_/A conf_hcb[53] _3951_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_50_105 VGND VPWR sky130_fd_sc_hd__decap_12
X_6670_ _6670_/A _7698_/Q _6670_/C _6670_/D _6670_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_3882_ _3882_/A _6269_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_91_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_330 VGND VPWR sky130_fd_sc_hd__decap_4
X_5621_ _5621_/A _5622_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_5552_ _7588_/Q _5552_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_144_221 VGND VPWR sky130_fd_sc_hd__decap_8
X_4503_ _7615_/Q _4503_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5483_ _5188_/X _5483_/B _5488_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_144_276 VGND VPWR sky130_fd_sc_hd__decap_6
X_4434_ _4427_/X _4433_/Y _4417_/X _4435_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7222_ _7222_/A _7162_/X _7224_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_12
X_4365_ _4417_/A _4365_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_99_853 VGND VPWR sky130_fd_sc_hd__fill_1
X_7153_ _7153_/A _7153_/B _7153_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_113_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_803 VGND VPWR sky130_fd_sc_hd__decap_12
X_7084_ _7053_/C _7079_/B _7067_/Y _6833_/X _7053_/X _7085_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6104_ _4954_/A north_single_in[3] _4950_/Y _6104_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_112_195 VGND VPWR sky130_fd_sc_hd__decap_8
X_6035_ _6034_/Y _6035_/B east_clb_input[0] VGND VPWR sky130_fd_sc_hd__nor2_4
X_4296_ _4281_/X _4294_/Y _4295_/X _4297_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_132_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_794 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_411 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_764 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_444 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_488 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6937_ _6807_/A1 _6934_/Y _6936_/Y _6938_/D VGND VPWR sky130_fd_sc_hd__a21oi_4
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6868_ _6866_/A _4151_/A _6868_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_23_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_661 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5819_ _7548_/Q _5819_/B south_double_in[2] _5819_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_10_514 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_886 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_6799_ _6798_/X _6812_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_10_558 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_148_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_210 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_413 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_216 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_569 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_580 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_260 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_603 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_591 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_282 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_93 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_447 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_672 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_552 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_243 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_257 VGND VPWR sky130_fd_sc_hd__decap_4
X_4150_ _6851_/B _4151_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_122_493 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_633 VGND VPWR sky130_fd_sc_hd__decap_8
X_4081_ _4067_/X conf_hcb[31] _4081_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_95_355 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_901 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_388 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_528 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_260 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_753 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_731 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_444 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_561 VGND VPWR sky130_fd_sc_hd__fill_2
X_4983_ _4974_/A conf_sb[15] _4986_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_3934_ _6396_/A _6427_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6722_ _6722_/A _4086_/A _6723_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_16_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_6653_ _6658_/C _6655_/A _6704_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_3865_ _6257_/A _6286_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_149_379 VGND VPWR sky130_fd_sc_hd__decap_12
X_5604_ _5813_/A _5534_/X _5604_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_31_171 VGND VPWR sky130_fd_sc_hd__decap_12
X_6584_ _6614_/A _6619_/B _6585_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_3796_ _3791_/Y _3796_/B _3796_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_145_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_145_530 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5535_ _4660_/Y _4664_/Y _5536_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_145_574 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_5466_ _5465_/X _5466_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_4417_ _4417_/A _4417_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7205_ _4395_/X _7201_/B _7164_/X _7269_/D _7205_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_99_672 VGND VPWR sky130_fd_sc_hd__decap_6
X_5397_ _5439_/A _5397_/B _5398_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_143_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_7136_ _7126_/C _7101_/B _7131_/C _7127_/B _7136_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_101_622 VGND VPWR sky130_fd_sc_hd__fill_1
X_4348_ _4249_/A _4368_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_87_845 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_4279_ _4249_/A _4285_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7067_ _7079_/C _7067_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_100_154 VGND VPWR sky130_fd_sc_hd__fill_1
X_6018_ _6016_/X _6017_/Y _6018_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_27_444 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_252 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_68 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_105 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_733 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_337 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_574 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_788 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_224 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_471 VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_6_0_clk clkbuf_3_7_0_clk/A clkbuf_3_6_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_93_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_720 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_701 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_85 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_723 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_499 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_299 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5320_ _5316_/X _5320_/B _5320_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_142_533 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_224 VGND VPWR sky130_fd_sc_hd__decap_12
X_5251_ _5250_/Y _5253_/B _5251_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_142_566 VGND VPWR sky130_fd_sc_hd__decap_12
X_4202_ _4202_/A _4202_/B _4202_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_130_739 VGND VPWR sky130_fd_sc_hd__decap_12
X_5182_ _5928_/A _5182_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_96_653 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_642 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_804 VGND VPWR sky130_fd_sc_hd__decap_3
X_4133_ _4104_/A _4133_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_889 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_867 VGND VPWR sky130_fd_sc_hd__decap_3
X_4064_ _7695_/Q _4064_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_110_474 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_742 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_580 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_797 VGND VPWR sky130_fd_sc_hd__decap_8
X_7754_ _3736_/Y _7754_/Q _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_767 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_110 VGND VPWR sky130_fd_sc_hd__decap_12
X_6705_ _7156_/A _6706_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4966_ _4905_/X _4966_/X VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3917_ _3892_/X _6389_/C _3912_/X _3918_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7685_ _7685_/D _4128_/A _7759_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_22_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4897_ _4891_/X _4896_/Y _4882_/X _4898_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_51_299 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_3848_ _3834_/X _3847_/Y _3825_/X _3848_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6636_ _6636_/A _6636_/B _6636_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6567_ _6525_/X _6536_/D _6553_/C _6502_/X _6536_/X _6568_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_3779_ _3733_/A _3779_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_500 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_725 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_5518_ _5518_/A _5518_/B _5518_/C _5518_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_6498_ _6492_/X _6494_/Y _6495_/X _6497_/Y _6500_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_79_609 VGND VPWR sky130_fd_sc_hd__fill_1
X_5449_ _5447_/X _5448_/X _5449_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_87_620 VGND VPWR sky130_fd_sc_hd__decap_12
X_7119_ _7119_/A _7119_/B _7124_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_75_826 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_388 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_807 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_550 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_786 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_380 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_594 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_572 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_77 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_806 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_664 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_141 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_349 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_360 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_653 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_122 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_561 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_263 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_572 VGND VPWR sky130_fd_sc_hd__decap_8
X_4820_ _6001_/B _4821_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_73_391 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_767 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_491 VGND VPWR sky130_fd_sc_hd__decap_8
X_4751_ _5884_/A _5827_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_3702_ _3702_/A conf_hcb[99] _3705_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7470_ _7470_/HI north_clb_input[22] VGND VPWR sky130_fd_sc_hd__conb_1
X_4682_ _5635_/B _4682_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_147_647 VGND VPWR sky130_fd_sc_hd__decap_12
X_6421_ _6386_/A _6400_/B _6419_/Y _6420_/X _6415_/X _6421_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_146_168 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_861 VGND VPWR sky130_fd_sc_hd__decap_12
X_6352_ _6346_/X _6349_/Y _6350_/X _6351_/X _6352_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_143_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_690 VGND VPWR sky130_fd_sc_hd__decap_12
X_6283_ _6283_/A _6283_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_115_544 VGND VPWR sky130_fd_sc_hd__decap_4
X_5303_ _5279_/X _4554_/X _5303_/C _4545_/X _5303_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_142_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_428 VGND VPWR sky130_fd_sc_hd__fill_1
X_5234_ _4522_/A _5234_/B _5169_/A _5169_/B _5234_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_69_642 VGND VPWR sky130_fd_sc_hd__decap_6
X_5165_ _5178_/A _5164_/X _4503_/X _5165_/D _5166_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_96_450 VGND VPWR sky130_fd_sc_hd__decap_8
X_4116_ _4110_/A conf_hcb[26] _4116_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_163 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_271 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_483 VGND VPWR sky130_fd_sc_hd__decap_4
X_5096_ _5096_/A _5096_/B _5096_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4047_ _7698_/Q _6644_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_83_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_380 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_206 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_756 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_239 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_228 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_217 VGND VPWR sky130_fd_sc_hd__decap_3
X_5998_ _5998_/A _5980_/A _5996_/X _5999_/D VGND VPWR sky130_fd_sc_hd__and3_4
X_7737_ _7737_/D _7737_/Q _7734_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_24_288 VGND VPWR sky130_fd_sc_hd__decap_12
X_4949_ _4925_/X _4949_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_137_113 VGND VPWR sky130_fd_sc_hd__decap_8
X_7668_ _4231_/Y _7043_/A _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_450 VGND VPWR sky130_fd_sc_hd__decap_8
X_6619_ _6619_/A _6619_/B _6619_/C _4020_/A _6619_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_152_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_157 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_360 VGND VPWR sky130_fd_sc_hd__decap_3
X_7599_ _4601_/Y _5423_/B _7592_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_3_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_800 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_130 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_601 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_837 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_111 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_689 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_76 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_659 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_350 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_586 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_748 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_597 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_617 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_476 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_73 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_62 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_149 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_409 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6970_ _6706_/A _6922_/X _6970_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_689 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_155 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_637 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_626 VGND VPWR sky130_fd_sc_hd__fill_2
X_5921_ _4785_/X _5944_/D _5919_/X _7247_/D _5953_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_65_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_350 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_715 VGND VPWR sky130_fd_sc_hd__decap_4
X_5852_ _5837_/X _5852_/B _5852_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4803_ _4802_/Y _4803_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5783_ _5778_/X _5779_/X _5780_/X _5782_/Y _5783_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_7522_ _4995_/Y _4993_/A _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_269 VGND VPWR sky130_fd_sc_hd__decap_12
X_4734_ _4744_/A conf_vcb[17] _4734_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_147_433 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_113 VGND VPWR sky130_fd_sc_hd__decap_8
X_7453_ _7453_/HI east_clb_input[29] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_119_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_4665_ _4664_/Y _5574_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_6404_ _6392_/B _6404_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7384_ _7357_/X _7353_/D _7374_/X _7256_/D _7384_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_4596_ _4612_/A conf_vcb[42] _4596_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6335_ _3895_/X _3901_/X _6345_/C _6601_/D _6365_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_1_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_748 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_867 VGND VPWR sky130_fd_sc_hd__decap_12
X_6266_ _6265_/X _6266_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6197_ _6218_/B _6224_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_130_377 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_366 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_910 VGND VPWR sky130_fd_sc_hd__decap_4
X_5217_ _5218_/A clb_output[2] _5217_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5148_ _7749_/Q _5146_/Y _5147_/X _5148_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_151_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_5079_ _3693_/A _5744_/A _5079_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_29_358 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_542 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_380 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_708 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_411 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_770 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_589 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_466 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_425 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_21 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_468 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_87 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_652 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_601 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_31 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_431 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_464 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_306 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_531 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_339 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_884 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_523 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_208 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_455 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4450_ _4427_/X _4449_/X _4444_/X _4450_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4381_ _5154_/A _5155_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_131_108 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_160 VGND VPWR sky130_fd_sc_hd__fill_1
X_6120_ _6163_/D _6131_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_140_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_589 VGND VPWR sky130_fd_sc_hd__fill_2
X_6051_ _7535_/Q _5225_/B _4931_/Y _6051_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_85_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_792 VGND VPWR sky130_fd_sc_hd__fill_1
X_5002_ _5015_/A conf_sb[11] _5002_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_26_328 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_689 VGND VPWR sky130_fd_sc_hd__decap_8
X_6953_ _6921_/A _4171_/X _6946_/C _6824_/X _6950_/X _6953_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_53_147 VGND VPWR sky130_fd_sc_hd__decap_6
X_6884_ _6884_/A _6889_/B _6881_/Y _6817_/D _6884_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5904_ _5931_/B _5948_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_5835_ _5832_/X _5834_/X _5827_/A _5836_/B VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_394 VGND VPWR sky130_fd_sc_hd__decap_3
X_5766_ _5773_/B _5767_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_7505_ west_double_in[3] east_double_out[1] VGND VPWR sky130_fd_sc_hd__buf_2
XFILLER_148_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_241 VGND VPWR sky130_fd_sc_hd__decap_3
X_4717_ _4723_/A conf_vcb[20] _4722_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5697_ _4714_/A _4720_/A _5696_/X _5697_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_107_105 VGND VPWR sky130_fd_sc_hd__decap_12
X_7436_ _7436_/HI east_clb_input[12] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_30_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_4648_ _4624_/X _5581_/A _4642_/X _4649_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_146_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_138 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_108 VGND VPWR sky130_fd_sc_hd__decap_12
X_7367_ _7366_/X _7367_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4579_ _4568_/X conf_vcb[45] _4579_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6318_ _6317_/X _6336_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_193 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_182 VGND VPWR sky130_fd_sc_hd__fill_1
X_7298_ _7306_/A _7306_/B _7290_/A _7299_/B VGND VPWR sky130_fd_sc_hd__or3_4
X_6249_ _6248_/Y _6249_/B _6249_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_130_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_209 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_434 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_607 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_23_0_clk clkbuf_5_23_0_clk/A _7713_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_111_62 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_821 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_375 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_436 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_642 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_182 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_163 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_147 VGND VPWR sky130_fd_sc_hd__decap_12
X_3950_ _3950_/A _3959_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_17_862 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_117 VGND VPWR sky130_fd_sc_hd__decap_12
X_3881_ _6270_/B _3882_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_84_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5620_ _5619_/X _5664_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_32_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_252 VGND VPWR sky130_fd_sc_hd__decap_8
X_5551_ _5539_/X _5541_/X _5576_/C _5277_/X _5592_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_145_745 VGND VPWR sky130_fd_sc_hd__decap_12
X_4502_ _4479_/X conf_vcb[58] _4508_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7221_ _7220_/Y _7221_/B _7222_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_5482_ _5503_/A _4626_/X _5491_/C north_double_out[3] _5514_/B VGND VPWR sky130_fd_sc_hd__nor4_4
X_4433_ _7628_/Q _4433_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7152_ _7150_/Y _7151_/X _7153_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_4364_ _4090_/A _4417_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_113_675 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_815 VGND VPWR sky130_fd_sc_hd__decap_6
X_4295_ _4272_/A _4295_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7083_ _7053_/X _7083_/B _7083_/C _7085_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_59_707 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_206 VGND VPWR sky130_fd_sc_hd__decap_8
X_6103_ _6103_/A east_single_in[2] _6103_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_140_483 VGND VPWR sky130_fd_sc_hd__decap_8
X_6034_ _6034_/A _6033_/B _6034_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_55_902 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_581 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_721 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_486 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_732 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_648 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_497 VGND VPWR sky130_fd_sc_hd__decap_8
X_6936_ _6934_/Y _6935_/X _6916_/A _6936_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_54_456 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6867_ _6867_/A _6867_/B _6859_/A _6858_/X _6867_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6798_ _6779_/A _4122_/A _6798_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5818_ _4877_/A north_double_in[1] _4873_/Y _5818_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_5749_ _6423_/A west_double_out[1] VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_108_425 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_447 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_436 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_203 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_255 VGND VPWR sky130_fd_sc_hd__decap_12
X_7419_ _7417_/Y _7418_/X _7764_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_2_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_642 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_364 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_228 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_44 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_762 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_529 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_456 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_798 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_397 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_266 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_255 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_4080_ _4075_/Y _4080_/B _7693_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_37_913 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_272 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_787 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_467 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_404 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_681 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_629 VGND VPWR sky130_fd_sc_hd__decap_8
X_4982_ _4982_/A _4981_/X _4982_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_51_415 VGND VPWR sky130_fd_sc_hd__decap_12
X_6721_ _6721_/A _6769_/D _6773_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_3933_ _3919_/X conf_hcb[56] _3933_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6652_ _6652_/A _6652_/B _4035_/Y _6655_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_3864_ _6253_/C _6257_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_32_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_5603_ _5603_/A _5534_/X _5603_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_6583_ _6583_/A _6583_/B _6642_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_118_701 VGND VPWR sky130_fd_sc_hd__fill_1
X_3795_ _3779_/X _3792_/Y _3794_/X _3796_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_11_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_891 VGND VPWR sky130_fd_sc_hd__decap_12
X_5534_ _4640_/Y _5534_/B _5534_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_145_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_417 VGND VPWR sky130_fd_sc_hd__decap_8
X_5465_ _5491_/A _5465_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4416_ _4416_/A _4416_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7204_ _7163_/A _4412_/X _7166_/X _7201_/B _7204_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_105_428 VGND VPWR sky130_fd_sc_hd__decap_4
X_7135_ _7131_/C _4261_/X _7134_/Y _6420_/A _7131_/X _7135_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5396_ _5404_/C _5396_/B _5457_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_143_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_472 VGND VPWR sky130_fd_sc_hd__fill_1
X_4347_ _4347_/A _4346_/X _4347_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_59_515 VGND VPWR sky130_fd_sc_hd__decap_8
X_4278_ _4278_/A _4278_/B _4278_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_86_356 VGND VPWR sky130_fd_sc_hd__decap_12
X_7066_ _7062_/X _7063_/X _7064_/X _7065_/Y _7066_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_59_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_177 VGND VPWR sky130_fd_sc_hd__decap_8
X_6017_ _5988_/A _5988_/B _6008_/Y _5877_/X _6014_/X _6017_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_100_188 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_283 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_264 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_415 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6919_ _6938_/B _6946_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_70_768 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_312 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_723 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_745 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_349 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_816 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_315 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_849 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_584 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_212 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_317 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_586 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_545 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_236 VGND VPWR sky130_fd_sc_hd__decap_4
X_5250_ _5171_/X _5174_/A _5249_/X _5250_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_142_578 VGND VPWR sky130_fd_sc_hd__fill_2
X_4201_ _4191_/X _6994_/B _4182_/X _4202_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_47_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_824 VGND VPWR sky130_fd_sc_hd__decap_8
X_5181_ south_single_out[2] _5928_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_95_120 VGND VPWR sky130_fd_sc_hd__fill_2
X_4132_ _4139_/A conf_hcb[23] _4132_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_51 VGND VPWR sky130_fd_sc_hd__decap_8
X_4063_ _4052_/A conf_hcb[34] _4066_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_84_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_710 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_497 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_562 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_754 VGND VPWR sky130_fd_sc_hd__decap_4
X_7753_ _7753_/D _3738_/A _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_779 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_459 VGND VPWR sky130_fd_sc_hd__decap_12
X_4965_ _7528_/Q _4965_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_51_245 VGND VPWR sky130_fd_sc_hd__decap_4
X_3916_ _6435_/A _6389_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_6704_ _6704_/A _6704_/B _6707_/B VGND VPWR sky130_fd_sc_hd__and2_4
XPHY_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_267 VGND VPWR sky130_fd_sc_hd__decap_8
X_7684_ _4138_/Y _7684_/Q _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_621 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_632 VGND VPWR sky130_fd_sc_hd__decap_8
X_4896_ _7543_/Q _4896_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_149_166 VGND VPWR sky130_fd_sc_hd__fill_2
X_3847_ _7732_/Q _3847_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_6635_ _6633_/Y _6635_/B _6636_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_6566_ _6536_/X _6539_/Y _6566_/C _6568_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_118_520 VGND VPWR sky130_fd_sc_hd__decap_8
X_3778_ _3787_/A conf_hcb[83] _3782_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_146_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_361 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_553 VGND VPWR sky130_fd_sc_hd__decap_12
X_5517_ _5517_/A _5517_/B _5518_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_6497_ _3956_/X _6455_/X _6470_/A _6497_/D _6497_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_105_214 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_5448_ _5450_/B _5318_/X _5450_/A _5405_/B _5448_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_120_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5379_ _5379_/A _5353_/Y _5378_/X _5379_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_7118_ _4255_/X _4261_/X _7127_/C _6334_/A _7145_/B VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_87_632 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_453 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_698 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_315 VGND VPWR sky130_fd_sc_hd__decap_8
X_7049_ _7049_/A _7050_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_74_337 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_326 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_743 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_819 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_754 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_3 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_267 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_818 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_632 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_614 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_564 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_93 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_898 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_729 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_781 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_632 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_304 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_134 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_765 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_908 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_746 VGND VPWR sky130_fd_sc_hd__decap_12
X_4750_ _4744_/A conf_vcb[14] _4750_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3701_ _3701_/A _3700_/X _3701_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_4681_ _4735_/A _4681_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_659 VGND VPWR sky130_fd_sc_hd__decap_12
X_6420_ _6420_/A _6420_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6351_ _3894_/Y _6321_/X _6351_/C _6351_/D _6351_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_128_873 VGND VPWR sky130_fd_sc_hd__decap_12
X_5302_ _5303_/C _4545_/X _5301_/Y south_double_out[0] _5298_/X _5302_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_154_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_567 VGND VPWR sky130_fd_sc_hd__decap_3
X_6282_ _6278_/X _6279_/X _6280_/X _6281_/Y _6282_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_103_707 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_206 VGND VPWR sky130_fd_sc_hd__decap_8
X_5233_ south_double_out[2] _5229_/X _5232_/X _5233_/Y VGND VPWR sky130_fd_sc_hd__a21boi_4
XFILLER_102_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_440 VGND VPWR sky130_fd_sc_hd__decap_3
X_5164_ _5164_/A _5164_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4115_ _4115_/A _4114_/X _7688_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_68_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_827 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_805 VGND VPWR sky130_fd_sc_hd__decap_8
X_5095_ _7759_/Q _5744_/A _5095_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_68_175 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_529 VGND VPWR sky130_fd_sc_hd__decap_12
X_4046_ _4052_/A conf_hcb[37] _4046_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_84_668 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_178 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_207 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_392 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_229 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_218 VGND VPWR sky130_fd_sc_hd__decap_3
X_5997_ _5982_/B _5997_/B _5998_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_80_874 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_7736_ _3827_/Y _7736_/Q _7734_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_598 VGND VPWR sky130_fd_sc_hd__fill_1
X_4948_ _4960_/A conf_sb[23] _4948_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_33_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_4879_ _4876_/Y _4879_/B _7547_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7667_ _7667_/D _7054_/A _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6618_ _6619_/C _4020_/X _6617_/Y _6420_/X _6614_/X _6618_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
Xclkbuf_3_5_0_clk clkbuf_3_5_0_clk/A clkbuf_3_5_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_7598_ _7598_/D _5395_/A _7592_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_152_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_117 VGND VPWR sky130_fd_sc_hd__decap_12
X_6549_ _6545_/X _6546_/X _6547_/X _6548_/Y _6549_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_106_534 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_394 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_375 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_418 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_397 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_315 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_849 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_808 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_882 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_863 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_362 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_245 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_32 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_451 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_440 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_629 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_106 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_548 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_348 VGND VPWR sky130_fd_sc_hd__decap_3
X_5920_ _5068_/Y _7247_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_65_189 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_318 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_381 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_362 VGND VPWR sky130_fd_sc_hd__decap_4
X_5851_ _5844_/A _5867_/B _5850_/X _5851_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_4802_ _4802_/A _4802_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5782_ _5754_/X _5750_/D _5782_/C _7192_/D _5782_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_22_738 VGND VPWR sky130_fd_sc_hd__decap_8
X_7521_ _5001_/Y _4999_/A _7526_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4733_ _4733_/A _4744_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_445 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_136 VGND VPWR sky130_fd_sc_hd__decap_8
X_7452_ _7452_/HI east_clb_input[28] VGND VPWR sky130_fd_sc_hd__conb_1
X_6403_ _6403_/A _6403_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4664_ _4664_/A _4664_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7383_ _7383_/A _4482_/A _7407_/A _4492_/X _7383_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4595_ _4510_/A _4612_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6334_ _6334_/A _6601_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_143_684 VGND VPWR sky130_fd_sc_hd__decap_12
X_6265_ _6264_/X _6265_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_116_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_215 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_334 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_559 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_248 VGND VPWR sky130_fd_sc_hd__decap_12
X_5216_ _5216_/A east_clb_output[1] _5216_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6196_ _6228_/C _6196_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_131_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_389 VGND VPWR sky130_fd_sc_hd__decap_8
X_5147_ _5147_/A _3761_/A _5142_/A _5087_/Y _5147_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_28_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_432 VGND VPWR sky130_fd_sc_hd__decap_12
X_5078_ north_clb_output[1] _5744_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_57_668 VGND VPWR sky130_fd_sc_hd__decap_3
X_4029_ _4029_/A _6619_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_71_104 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_863 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_693 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_682 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_7719_ _7719_/D _6381_/C _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_138_423 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_3 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_832 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_640 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_66 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_99 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_345 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_664 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_581 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_43 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_421 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_592 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_808 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_679 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_627 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_860 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_435 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_137 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_370 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_682 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_557 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_80 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_916 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_128 VGND VPWR sky130_fd_sc_hd__decap_12
X_4380_ _4384_/A conf_vcb[81] _4383_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_125_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_356 VGND VPWR sky130_fd_sc_hd__decap_8
X_6050_ _6050_/A _6046_/X _6050_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_100_529 VGND VPWR sky130_fd_sc_hd__decap_12
X_5001_ _4997_/Y _5001_/B _5001_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_94_796 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_318 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_178 VGND VPWR sky130_fd_sc_hd__decap_12
X_6952_ _6947_/X _6949_/Y _6950_/X _6951_/Y _6952_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_81_457 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_498 VGND VPWR sky130_fd_sc_hd__decap_8
X_6883_ _6883_/A _6883_/B _6855_/X _6879_/B _6883_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5903_ _5944_/C _5906_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5834_ _5869_/B _5834_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_811 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_568 VGND VPWR sky130_fd_sc_hd__decap_12
X_5765_ _5753_/X _5773_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_148_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_607 VGND VPWR sky130_fd_sc_hd__decap_12
X_7504_ west_double_in[2] east_double_out[0] VGND VPWR sky130_fd_sc_hd__buf_2
X_4716_ _4713_/Y _4716_/B _7578_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_5696_ _7577_/Q _5560_/X _5561_/X _5692_/X _5696_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_7435_ _7435_/HI east_clb_input[11] VGND VPWR sky130_fd_sc_hd__conb_1
XFILLER_135_426 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_4647_ _5576_/A _5581_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_7366_ _7365_/X _7366_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6317_ _3905_/Y _6343_/D _6317_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4578_ _4575_/Y _4578_/B _7603_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_143_492 VGND VPWR sky130_fd_sc_hd__decap_8
X_7297_ _7297_/A _7306_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_1_428 VGND VPWR sky130_fd_sc_hd__decap_6
X_6248_ _6248_/A _6247_/B _6248_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_89_568 VGND VPWR sky130_fd_sc_hd__decap_8
X_6179_ _6179_/A _6179_/B _6243_/C _6122_/B _6179_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_85_730 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_454 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_498 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_863 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_682 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_833 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_321 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_877 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_579 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_459 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_71 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_494 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_755 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_276 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_129 VGND VPWR sky130_fd_sc_hd__decap_12
X_3880_ _6263_/B _6270_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_32_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_354 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_590 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5550_ _5559_/B _5576_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_415 VGND VPWR sky130_fd_sc_hd__fill_1
X_4501_ _4496_/Y _4500_/X _7616_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_8_572 VGND VPWR sky130_fd_sc_hd__decap_8
X_5481_ _5481_/A _5491_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_757 VGND VPWR sky130_fd_sc_hd__decap_12
X_4432_ _4436_/A conf_vcb[71] _4435_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XANTENNA_0 clb_cout VGND VPWR sky130_fd_sc_hd__diode_2
X_7220_ _7220_/A _7171_/X _7220_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_125_470 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_7151_ _7126_/C _4271_/X horizontal_global[1] _7110_/A _7151_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4363_ _7641_/Q _4363_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_140_440 VGND VPWR sky130_fd_sc_hd__decap_12
X_6102_ _6102_/A _6102_/B _7159_/A _6102_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_4294_ _5075_/B _4294_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7082_ _7082_/A _7082_/B _7083_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_59_719 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_462 VGND VPWR sky130_fd_sc_hd__decap_8
X_6033_ _6033_/A _6033_/B _6035_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_86_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_348 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_741 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_421 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_763 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_251 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_593 VGND VPWR sky130_fd_sc_hd__decap_8
X_6935_ _6923_/B _6803_/X _6804_/X _6931_/A _6935_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_608 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6866_ _6866_/A _6867_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_23_855 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6797_ _6811_/C _4123_/X _6784_/X _6786_/X _6797_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5817_ _5819_/B east_double_in[2] _5817_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_50_685 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_5748_ _7758_/Q _5746_/Y _5747_/X _6423_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_22_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_245 VGND VPWR sky130_fd_sc_hd__fill_1
X_5679_ _5679_/A _5715_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_135_267 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_407 VGND VPWR sky130_fd_sc_hd__decap_12
X_7418_ _5089_/A _4911_/A _3699_/A _7418_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_2_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_7349_ _7348_/Y _7347_/X _7349_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_89_310 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_203 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_737 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_248 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_52 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_269 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_733 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_276 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_671 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_641 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_521 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_613 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_280 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_608 VGND VPWR sky130_fd_sc_hd__fill_1
X_4981_ _4975_/X _4980_/Y _4966_/X _4981_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_149_304 VGND VPWR sky130_fd_sc_hd__fill_1
X_3932_ _3927_/Y _3932_/B _3932_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6720_ _6720_/A _6720_/B _4064_/Y _6769_/D VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_149_326 VGND VPWR sky130_fd_sc_hd__decap_12
X_3863_ _3863_/A _3863_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6651_ _6688_/D _6652_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_825 VGND VPWR sky130_fd_sc_hd__decap_4
X_6582_ _6582_/A _6582_/B _4012_/A _4018_/Y _6583_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_5602_ _5601_/Y _5602_/B _5603_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_31_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_696 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_510 VGND VPWR sky130_fd_sc_hd__decap_12
X_3794_ _3854_/A _3794_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5533_ _7588_/Q _4664_/A _5533_/C _4655_/Y _5534_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_118_735 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_5464_ _5460_/C _5491_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_145_598 VGND VPWR sky130_fd_sc_hd__decap_12
X_4415_ _4405_/A conf_vcb[74] _4419_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7203_ _7166_/X _4402_/X _7196_/C _5871_/X _7200_/X _7203_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_99_630 VGND VPWR sky130_fd_sc_hd__decap_8
X_5395_ _5395_/A _5406_/B _5395_/C _5427_/B _5396_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_132_248 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_5_22_0_clk clkbuf_5_23_0_clk/A _7715_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_99_641 VGND VPWR sky130_fd_sc_hd__decap_6
X_7134_ _7127_/C _7134_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_98_140 VGND VPWR sky130_fd_sc_hd__decap_12
X_4346_ _4327_/X _5211_/A _4341_/X _4346_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_101_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_685 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_4277_ _4252_/X _4276_/Y _4272_/X _4278_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7065_ _4222_/A _4229_/A _7072_/A _6053_/X _7065_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6016_ _6012_/X _6013_/Y _6014_/X _6015_/Y _6016_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_86_368 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_733 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_424 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_295 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_457 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_736 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6918_ _6917_/X _6921_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_14_129 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6849_ _6710_/A _6780_/X _6850_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_663 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_818 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_513 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_545 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_814 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_495 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_184 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_66 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_828 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_327 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_65 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_43 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_563 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_446 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_596 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_630 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_696 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_329 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_373 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_598 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_259 VGND VPWR sky130_fd_sc_hd__decap_12
X_4200_ _7012_/D _6994_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5180_ _5176_/B _5180_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_95_132 VGND VPWR sky130_fd_sc_hd__decap_8
X_4131_ _4100_/A _4139_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_74 VGND VPWR sky130_fd_sc_hd__decap_12
X_4062_ _4056_/Y _4062_/B _4062_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_84_839 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_700 VGND VPWR sky130_fd_sc_hd__fill_1
X_7752_ _3744_/Y _7752_/Q _7553_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4964_ _4960_/A conf_sb[19] _4964_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6703_ _6458_/X _6657_/A _6702_/X _6704_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_3915_ _3898_/A conf_hcb[59] _3915_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7683_ _4144_/Y _6857_/A _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_32_482 VGND VPWR sky130_fd_sc_hd__fill_1
X_4895_ _4889_/X conf_sb[34] _4898_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_3846_ _3846_/A conf_hcb[71] _3849_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6634_ _6619_/A _6623_/B _6510_/C _6590_/X _6635_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_6565_ _6565_/A _6565_/B _6566_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_3777_ _3706_/A _3787_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6496_ east_double_in[1] _6497_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_118_565 VGND VPWR sky130_fd_sc_hd__decap_12
X_5516_ _5466_/X _5468_/X _5496_/C _5515_/X _5479_/X _5517_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_5447_ _5447_/A _5447_/B _5447_/C _5447_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_154_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_557 VGND VPWR sky130_fd_sc_hd__decap_12
X_5378_ _5376_/X _5377_/Y _5378_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_113_270 VGND VPWR sky130_fd_sc_hd__decap_4
X_7117_ _7116_/X _7127_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_4329_ _4327_/X _5115_/A _4318_/X _4330_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_86_154 VGND VPWR sky130_fd_sc_hd__decap_8
X_7048_ _7045_/X _7047_/X _7049_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_27_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_202 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_611 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_830 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_535 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_419 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_93 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_752 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_828 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_699 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_157 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_777 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_703 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_714 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_725 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_544 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_758 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_588 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_408 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_257 VGND VPWR sky130_fd_sc_hd__decap_12
X_3700_ _4958_/A _5100_/A _3699_/X _3700_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_147_605 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_290 VGND VPWR sky130_fd_sc_hd__decap_12
X_4680_ _4696_/A conf_vcb[27] _4685_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6350_ _3905_/Y _6343_/D _6355_/C _6345_/B _6350_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5301_ _5282_/X _5301_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_143_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_321 VGND VPWR sky130_fd_sc_hd__decap_12
X_6281_ _6257_/A _6290_/D _6272_/C _6219_/D _6281_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_130_505 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_579 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_719 VGND VPWR sky130_fd_sc_hd__decap_12
X_5232_ _4522_/A _5234_/B _5232_/C _7614_/Q _5232_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_142_398 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_730 VGND VPWR sky130_fd_sc_hd__fill_2
X_5163_ _5161_/A _4999_/A north_single_in[0] _5161_/X _5162_/X south_single_out[0]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
X_4114_ _4104_/X _6800_/B _4091_/X _4114_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_68_187 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_839 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_316 VGND VPWR sky130_fd_sc_hd__decap_3
X_5094_ _7333_/D south_double_out[3] VGND VPWR sky130_fd_sc_hd__buf_1
X_4045_ _4039_/Y _4045_/B _7699_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_37_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_714 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_219 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VPWR sky130_fd_sc_hd__decap_3
X_5996_ _7558_/Q _4831_/A _5995_/X _5996_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_80_886 VGND VPWR sky130_fd_sc_hd__decap_12
X_7735_ _3831_/Y _6240_/A _7734_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_4947_ _4922_/X _4960_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_33_780 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_4878_ _4868_/X _5819_/B _4859_/X _4879_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7666_ _4243_/Y _7037_/B _7670_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6617_ _6610_/C _6617_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_3829_ _6240_/A _6192_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_20_463 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_607 VGND VPWR sky130_fd_sc_hd__decap_12
X_7597_ _7597_/D _5406_/B _7592_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_20_496 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_129 VGND VPWR sky130_fd_sc_hd__fill_1
X_6548_ _3984_/A _6552_/D _6555_/A _6481_/D _6548_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_106_524 VGND VPWR sky130_fd_sc_hd__fill_1
X_6479_ _3955_/A _6481_/B _6481_/C _6478_/X _6448_/X _6479_/X VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_133_365 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_579 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_387 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_730 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_251 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_327 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_669 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_875 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_257 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_227 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_126 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_82 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_151 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_376 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_102 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_593 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_894 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_330 VGND VPWR sky130_fd_sc_hd__decap_12
X_5850_ _5826_/B _5560_/X _5561_/X _5847_/A _5850_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_4801_ _4807_/A conf_vcb[5] _4806_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_5781_ south_single_in[1] _7192_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_4732_ _4728_/Y _4731_/X _7575_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_51 VGND VPWR sky130_fd_sc_hd__decap_8
X_7520_ _7520_/D _5003_/A _7522_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_7451_ _7451_/HI east_clb_input[27] VGND VPWR sky130_fd_sc_hd__conb_1
X_4663_ _4651_/X conf_vcb[30] _4668_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_147_457 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_608 VGND VPWR sky130_fd_sc_hd__fill_2
X_6402_ _6602_/A _6413_/A _6402_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7382_ _7357_/X _7353_/D _7374_/X _5932_/A _7353_/X _7382_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_4594_ _4590_/Y _4594_/B _4594_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6333_ _6332_/X _6345_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_115_310 VGND VPWR sky130_fd_sc_hd__fill_1
X_6264_ _6261_/X _6264_/B _6264_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_115_376 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_516 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_195 VGND VPWR sky130_fd_sc_hd__decap_8
X_5215_ _4522_/A _5234_/B _5229_/C _5229_/D _5215_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6195_ _3836_/A _6228_/C VGND VPWR sky130_fd_sc_hd__buf_1
Xclkbuf_4_15_0_clk clkbuf_3_7_0_clk/X clkbuf_5_31_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_97_794 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_260 VGND VPWR sky130_fd_sc_hd__decap_12
X_5146_ _3761_/A _5142_/X _5143_/X _5144_/X _5145_/X _5146_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_28_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_444 VGND VPWR sky130_fd_sc_hd__decap_12
X_5077_ _5076_/Y north_double_out[2] VGND VPWR sky130_fd_sc_hd__buf_1
X_4028_ _6582_/B _4029_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_84_488 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_127 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_511 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_894 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_661 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_352 VGND VPWR sky130_fd_sc_hd__decap_12
X_5979_ _5988_/A _5988_/B _5979_/C _5979_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_52_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_536 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_903 VGND VPWR sky130_fd_sc_hd__decap_12
X_7718_ _3932_/Y _6387_/A _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_100_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_750 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_435 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_457 VGND VPWR sky130_fd_sc_hd__fill_1
X_7649_ _4330_/Y _4328_/A _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_844 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_195 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_184 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_621 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_379 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_271 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_11 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_676 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_872 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_447 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_341 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_352 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_672 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_293 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_776 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_803 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_750 VGND VPWR sky130_fd_sc_hd__fill_2
X_5000_ _4998_/X _4999_/Y _4989_/X _5001_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_121_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_669 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_4_0_clk clkbuf_3_5_0_clk/A clkbuf_3_4_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_81_436 VGND VPWR sky130_fd_sc_hd__fill_2
X_6951_ _6927_/A _6946_/B _6941_/C _6754_/X _6951_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_6882_ _6884_/A _6889_/B _6881_/Y _6677_/X _6878_/X _6882_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_81_469 VGND VPWR sky130_fd_sc_hd__fill_2
X_5902_ _5935_/A _5944_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_46_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_171 VGND VPWR sky130_fd_sc_hd__fill_1
X_5833_ _5833_/A _5869_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_834 VGND VPWR sky130_fd_sc_hd__decap_8
X_7503_ clb_cout east_clb_cin VGND VPWR sky130_fd_sc_hd__buf_2
X_5764_ _5764_/A _5807_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_147_221 VGND VPWR sky130_fd_sc_hd__decap_12
X_4715_ _4708_/X _5715_/A _4698_/X _4716_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_5695_ _5773_/A _5687_/Y _5700_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_148_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_619 VGND VPWR sky130_fd_sc_hd__decap_4
X_7434_ _7434_/HI east_clb_input[10] VGND VPWR sky130_fd_sc_hd__conb_1
X_4646_ _5533_/C _5576_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_135_449 VGND VPWR sky130_fd_sc_hd__decap_12
X_7365_ _7365_/A _7364_/X _7365_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4577_ _4570_/X _5342_/A _4560_/X _4578_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6316_ _3887_/Y _6316_/B _6316_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_131_611 VGND VPWR sky130_fd_sc_hd__decap_12
X_7296_ _7317_/B _7297_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_6247_ _6246_/Y _6247_/B _6249_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_89_558 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_187 VGND VPWR sky130_fd_sc_hd__decap_8
X_6178_ horizontal_global[1] _6243_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_198 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_591 VGND VPWR sky130_fd_sc_hd__decap_8
X_5129_ _3746_/A _5125_/X _5126_/X _5127_/X _5128_/X _5129_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_29_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_797 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_466 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_285 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_842 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_875 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_694 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_672 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_385 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_333 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_867 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_733 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_769 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_224 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_482 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_633 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_622 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_162 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_606 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_617 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_299 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_363 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_661 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_171 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4500_ _4481_/X _4497_/Y _4499_/X _4500_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_5480_ _7593_/Q _5480_/B _5481_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_145_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_4431_ _4426_/Y _4430_/X _7629_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XANTENNA_1 clb_cout VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_482 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_322 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_300 VGND VPWR sky130_fd_sc_hd__decap_12
X_7150_ _7148_/X _7150_/B _7150_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_4362_ _4368_/A conf_vcb[84] _4362_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_140_452 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_655 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_366 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_355 VGND VPWR sky130_fd_sc_hd__decap_8
X_6101_ clb_output[1] _7159_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_4293_ _4285_/A conf_vcb[99] _4293_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7081_ _7053_/C _7079_/B _7072_/Y _6362_/A _7078_/X _7082_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
X_6032_ _6031_/Y _6030_/X _6033_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_67_720 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_701 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_775 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_296 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_274 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_105 VGND VPWR sky130_fd_sc_hd__decap_12
X_6934_ _6924_/B _6934_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_266 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_672 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6865_ _6889_/A _4142_/X _6881_/A _6795_/D _6865_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_50_642 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6796_ _6779_/A _6811_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_5816_ _5816_/A _5096_/B _5816_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_23_878 VGND VPWR sky130_fd_sc_hd__decap_8
X_5747_ _5747_/A _7757_/Q _5747_/C _5100_/D _5747_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_41_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_7417_ conf_hcb[103] _3702_/A _7417_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_5678_ _5715_/C _5681_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_135_279 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_4629_ _4645_/A conf_vcb[36] _4632_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_150_227 VGND VPWR sky130_fd_sc_hd__fill_2
X_7348_ _7284_/A _7347_/B _7348_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_89_322 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_727 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_749 VGND VPWR sky130_fd_sc_hd__decap_12
X_7279_ _7243_/X _4439_/X _7215_/C _7237_/A _7279_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_77_528 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_208 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_550 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_764 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_883 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_639 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_436 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_56 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_683 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_517 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_669 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_292 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_553 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_531 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_767 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_661 VGND VPWR sky130_fd_sc_hd__decap_8
X_4980_ _7525_/Q _4980_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_51_428 VGND VPWR sky130_fd_sc_hd__fill_2
X_3931_ _3921_/X _6400_/B _3912_/X _3932_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_32_631 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_642 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_480 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_439 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_338 VGND VPWR sky130_fd_sc_hd__decap_12
X_6650_ _7698_/Q _6688_/D VGND VPWR sky130_fd_sc_hd__buf_1
X_3862_ _3886_/A conf_hcb[68] _3862_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6581_ _6581_/A _6581_/B clb_input[1] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_859 VGND VPWR sky130_fd_sc_hd__fill_2
X_5601_ _5526_/X _5543_/X _5601_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_3793_ _3793_/A _3854_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5532_ _5532_/A _5532_/B east_clb_input[7] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_31_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_522 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_202 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_257 VGND VPWR sky130_fd_sc_hd__decap_8
X_5463_ _5462_/X _5509_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_4414_ _4414_/A _4413_/X _7632_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7202_ _7197_/X _7199_/Y _7200_/X _7201_/Y _7202_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5394_ _5394_/A _5394_/B clb_input[9] VGND VPWR sky130_fd_sc_hd__nor2_4
X_7133_ _7128_/X _7130_/Y _7131_/X _7132_/X _7133_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_98_130 VGND VPWR sky130_fd_sc_hd__fill_1
X_4345_ _7645_/Q _5211_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_101_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_697 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_303 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_196 VGND VPWR sky130_fd_sc_hd__fill_1
X_4276_ _4276_/A _4276_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7064_ _7070_/A _7043_/A _7074_/A _7074_/B _7064_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_6015_ _5993_/A _5978_/A _5980_/A _7269_/D _6015_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_28_915 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_520 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_263 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_756 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_233 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_907 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_564 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6917_ _6938_/A _6917_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_52_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6848_ _6848_/A _6780_/X _6848_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_22_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_675 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_450 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6779_ _6779_/A _7686_/Q _4105_/A _4111_/Y _6780_/B VGND VPWR sky130_fd_sc_hd__or4_4
XPHY_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_246 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_525 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_279 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_524 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_74 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_314 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_282 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_78 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_561 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_62 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_520 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_266 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_620 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_717 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_385 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_750 VGND VPWR sky130_fd_sc_hd__decap_8
X_4130_ _4127_/Y _4130_/B _7685_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_123_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_433 VGND VPWR sky130_fd_sc_hd__decap_8
X_4061_ _4040_/X _6700_/B _4060_/X _4062_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_110_466 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_667 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_391 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_907 VGND VPWR sky130_fd_sc_hd__decap_8
X_7751_ _7751_/D _3746_/A _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_737 VGND VPWR sky130_fd_sc_hd__decap_8
X_4963_ _4960_/Y _4962_/X _4963_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_51_236 VGND VPWR sky130_fd_sc_hd__decap_8
X_3914_ _3908_/Y _3913_/X _3914_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6702_ _6657_/Y _6701_/X _6702_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_7682_ _7682_/D _6866_/A _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_149_146 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_135 VGND VPWR sky130_fd_sc_hd__decap_8
X_6633_ _6633_/A _6633_/B _6633_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_60_781 VGND VPWR sky130_fd_sc_hd__decap_3
X_4894_ _4894_/A _4894_/B _7544_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_3845_ _3840_/Y _3845_/B _3845_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_118_500 VGND VPWR sky130_fd_sc_hd__decap_8
X_6564_ _6525_/X _6536_/D _6555_/Y _6362_/X _6561_/X _6565_/B VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_118_511 VGND VPWR sky130_fd_sc_hd__decap_8
X_3776_ _3773_/Y _3776_/B _3776_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6495_ _3966_/Y _3972_/X _6452_/X _6486_/B _6495_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5515_ _5177_/X _5515_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_146_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_577 VGND VPWR sky130_fd_sc_hd__decap_3
X_5446_ _5444_/X _5445_/Y _5447_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_133_569 VGND VPWR sky130_fd_sc_hd__decap_4
X_5377_ _5348_/A _5348_/B _5368_/Y north_double_out[2] _5374_/X _5377_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
X_7116_ _7662_/Q _4270_/A _7116_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4328_ _4328_/A _5115_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_4259_ _7124_/B _4260_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_75_818 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_358 VGND VPWR sky130_fd_sc_hd__decap_8
X_7047_ _7069_/A _7037_/B _7047_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_47_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_428 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_737 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_770 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_842 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_300 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_84 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_99 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_645 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_775 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_764 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_604 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_133 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_306 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_701 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_520 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_873 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_789 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_269 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_5_21_0_clk clkbuf_5_21_0_clk/A _7703_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_142_300 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_385 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5300_ _5293_/X _5297_/Y _5298_/X _5299_/X _5300_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_143_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_333 VGND VPWR sky130_fd_sc_hd__decap_3
X_6280_ _6286_/A _6259_/A _6269_/A _3882_/A _6280_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_130_517 VGND VPWR sky130_fd_sc_hd__fill_2
X_5231_ _5226_/X _5228_/Y _5229_/X _5230_/Y _5231_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_5162_ _4993_/A west_single_in[0] _4999_/Y _5162_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_4113_ _6812_/B _6800_/B VGND VPWR sky130_fd_sc_hd__buf_1
X_5093_ _7546_/Q _4886_/Y east_double_in[2] _5091_/X _5092_/X _7333_/D VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_69_689 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_328 VGND VPWR sky130_fd_sc_hd__decap_8
X_4044_ _4040_/X _6658_/A _4031_/X _4045_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_68_199 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_862 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_726 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_692 VGND VPWR sky130_fd_sc_hd__decap_8
X_7734_ _3839_/Y _3835_/A _7734_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XPHY_209 VGND VPWR sky130_fd_sc_hd__decap_3
X_5995_ _5981_/B _5924_/X _5925_/X _5991_/X _5995_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_80_898 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_792 VGND VPWR sky130_fd_sc_hd__fill_1
X_4946_ _4943_/Y _4946_/B _7533_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_149_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_7665_ _4247_/Y _7148_/A _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4877_ _4877_/A _5819_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_6616_ _6611_/X _6613_/Y _6614_/X _6615_/X _6616_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_3828_ _3803_/A conf_hcb[74] _3828_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7596_ _4616_/Y _5518_/A _7592_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6547_ _6553_/A _6547_/B _6557_/A _6557_/B _6547_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_134_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_352 VGND VPWR sky130_fd_sc_hd__decap_8
X_3759_ _3755_/Y _3759_/B _7749_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_4_619 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_182 VGND VPWR sky130_fd_sc_hd__fill_1
X_6478_ _6145_/Y _6478_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_88_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5429_ _5440_/A _5440_/B _5412_/C _5296_/X _5425_/X _5429_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_59_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_100 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_764 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_742 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_464 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_869 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_775 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_829 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_851 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_670 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_35 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_810 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_715 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_692 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_887 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_269 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_707 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_910 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_792 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_137_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_374 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_366 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_163 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_140_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_388 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_114 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_317 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_147 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_489 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_618 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_87 VGND VPWR sky130_fd_sc_hd__decap_6
X_4800_ _4800_/A _4799_/X _4800_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_64_90 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_342 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_898 VGND VPWR sky130_fd_sc_hd__decap_12
X_5780_ _4729_/Y _4736_/A _5805_/A _4746_/X _5780_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_15_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_403 VGND VPWR sky130_fd_sc_hd__decap_6
X_4731_ _4708_/X _4730_/X _4725_/X _4731_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_9_74 VGND VPWR sky130_fd_sc_hd__decap_12
X_7450_ _7450_/HI east_clb_input[26] VGND VPWR sky130_fd_sc_hd__conb_1
X_4662_ _4662_/A _4661_/X _7588_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_6401_ _6401_/A _6401_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_116_801 VGND VPWR sky130_fd_sc_hd__decap_8
X_7381_ _7357_/X _4482_/A _7376_/X _7381_/D _7381_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_4593_ _4570_/X _5440_/A _4587_/X _4594_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6332_ _6330_/A _6332_/B _6332_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_6263_ _6294_/A _6263_/B _6264_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_88_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_163 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_314 VGND VPWR sky130_fd_sc_hd__decap_3
X_5214_ _5200_/X _5214_/A2 _5213_/X _5214_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_6194_ _6193_/X _6221_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_431 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_272 VGND VPWR sky130_fd_sc_hd__decap_3
X_5145_ _5142_/A west_single_in[2] _3761_/Y _5145_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_29_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_456 VGND VPWR sky130_fd_sc_hd__fill_2
X_5076_ _4290_/A _5074_/Y _5075_/X _5076_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4027_ _4017_/A conf_hcb[40] _4027_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_56_169 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_862 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_180 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_5978_ _5978_/A _5988_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_52_364 VGND VPWR sky130_fd_sc_hd__fill_2
X_7717_ _7717_/D _6396_/A _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_100_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_4929_ _4924_/Y _4928_/X _4929_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_7648_ _4334_/Y _7648_/Q _7657_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_99 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_428 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_672 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_661 VGND VPWR sky130_fd_sc_hd__decap_8
X_7579_ _7579_/D _5679_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_134_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_620 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_53 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_130 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_633 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_74 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_784 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_489 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_851 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_141_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_415 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_501 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_523 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_876 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_364 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_751 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_93 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_788 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_480 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_678 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_710 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_913 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_401 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_294 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_423 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6950_ _6965_/A _6915_/B _6917_/X _6941_/B _6950_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_54_618 VGND VPWR sky130_fd_sc_hd__decap_8
X_5901_ _5901_/A _5935_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_6881_ _6881_/A _6881_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_5832_ _5831_/X _5832_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_34_386 VGND VPWR sky130_fd_sc_hd__decap_8
X_5763_ _5763_/A _5764_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7502_ clb_output[7] clb_output_west[1] VGND VPWR sky130_fd_sc_hd__buf_2
X_4714_ _4714_/A _5715_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_147_233 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_592 VGND VPWR sky130_fd_sc_hd__decap_3
X_5694_ _5716_/A _5711_/D _5709_/A _5848_/D _5694_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_147_266 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_428 VGND VPWR sky130_fd_sc_hd__decap_12
X_7433_ _7433_/HI east_clb_input[9] VGND VPWR sky130_fd_sc_hd__conb_1
X_4645_ _4645_/A conf_vcb[33] _4645_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_620 VGND VPWR sky130_fd_sc_hd__decap_12
X_7364_ _7364_/A _7353_/B _7364_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4576_ _5351_/A _5342_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_6315_ _6330_/A _6315_/B _3893_/A _3900_/A _6316_/B VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_115_130 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_623 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_314 VGND VPWR sky130_fd_sc_hd__fill_1
X_7295_ _7295_/A _7306_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_1_419 VGND VPWR sky130_fd_sc_hd__decap_8
X_6246_ _6123_/X _6203_/X _6245_/X _6246_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_58_902 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_27 VGND VPWR sky130_fd_sc_hd__decap_12
X_6177_ _6173_/X _6176_/X _6177_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_5128_ _5125_/A west_single_in[3] _3746_/Y _5128_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_73_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_618 VGND VPWR sky130_fd_sc_hd__decap_8
X_5059_ _5059_/A _6031_/A _5059_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_84_297 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_459 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_640 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_846 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_69 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_745 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_726 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_130 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_769 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_518 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_754 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_743 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_732 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_721 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_776 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_264 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_467 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_437 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_629 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_267 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_375 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_334 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_367 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_14_0_clk clkbuf_3_7_0_clk/X clkbuf_5_29_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XPHY_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_2 clb_cout VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_129_288 VGND VPWR sky130_fd_sc_hd__decap_12
X_4430_ _4427_/X _4429_/X _4417_/X _4430_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_153_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_623 VGND VPWR sky130_fd_sc_hd__decap_6
X_6100_ _6100_/A _6100_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_98_312 VGND VPWR sky130_fd_sc_hd__decap_3
X_4361_ _4361_/A _4361_/B _7642_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_99_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_345 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_334 VGND VPWR sky130_fd_sc_hd__fill_2
X_4292_ _4292_/A _4291_/X _7657_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7080_ _7076_/X _7077_/Y _7078_/X _7079_/Y _7082_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_6031_ _6031_/A _6030_/B _6031_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_39_434 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_456 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_478 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_798 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_489 VGND VPWR sky130_fd_sc_hd__decap_4
X_6933_ _6733_/A _6922_/A _6938_/C VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_82_768 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_459 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_278 VGND VPWR sky130_fd_sc_hd__decap_3
X_6864_ _6864_/A _6905_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_35_684 VGND VPWR sky130_fd_sc_hd__decap_4
X_5815_ _7754_/Q _5736_/A _5815_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_22_312 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6795_ _4107_/X _6800_/B _6782_/X _6795_/D _6795_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_22_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_520 VGND VPWR sky130_fd_sc_hd__decap_12
X_5746_ _5747_/C _5737_/X _5739_/X _5743_/X _5745_/X _5746_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_10_518 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_389 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_715 VGND VPWR sky130_fd_sc_hd__decap_12
X_5677_ _5700_/A _5715_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_7416_ _7416_/A _7416_/B clb_input[12] VGND VPWR sky130_fd_sc_hd__nor2_4
X_4628_ _4628_/A _4627_/X _7594_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_7347_ _7346_/Y _7347_/B _7347_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_4559_ _5382_/A _5340_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_143_291 VGND VPWR sky130_fd_sc_hd__fill_1
X_7278_ _7276_/X _7277_/X _7278_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_89_356 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_6229_ _3837_/X _6224_/B _6229_/C west_double_out[1] _6229_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_106_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_507 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_851 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_404 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_234 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_297 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_492 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_470 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_695 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_676 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_575 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_553 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_409 VGND VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_3_0_clk clkbuf_3_3_0_clk/A clkbuf_4_7_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_135_781 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_461 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_566 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_291 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_816 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_562 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_201 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_543 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_779 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_245 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_459 VGND VPWR sky130_fd_sc_hd__decap_8
X_3930_ _6422_/D _6400_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_63_289 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_306 VGND VPWR sky130_fd_sc_hd__decap_3
X_3861_ _3832_/A _3886_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_20_816 VGND VPWR sky130_fd_sc_hd__decap_8
X_6580_ _6642_/A _6521_/X _6581_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_3792_ _7741_/Q _3792_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_82_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5600_ _5600_/A _5543_/X _5602_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_5531_ _5813_/A _5529_/B _5532_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7201_ _4395_/X _7201_/B _7182_/X _7201_/D _7201_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_5462_ _4630_/Y _5480_/B _5462_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4413_ _4400_/X _4412_/X _4390_/X _4413_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_114_910 VGND VPWR sky130_fd_sc_hd__decap_8
X_5393_ _7223_/A _5393_/B _5394_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7132_ _7132_/A _7132_/B _7132_/C _6416_/A _7132_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_99_654 VGND VPWR sky130_fd_sc_hd__decap_12
X_4344_ _4344_/A conf_vcb[88] _4347_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_464 VGND VPWR sky130_fd_sc_hd__decap_8
X_7063_ _4222_/A _4229_/A _7072_/A _6809_/X _7037_/X _7063_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_4275_ _4264_/A conf_vcb[103] _4278_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_6014_ _5981_/A _5990_/B _5976_/A _5978_/A _6014_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_100_136 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_253 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_404 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_381 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_768 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_576 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_407 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6916_ _6916_/A _6922_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_63_790 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6847_ _6846_/Y _6845_/X _6848_/A VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_6778_ _6778_/A _6778_/B north_clb_input[6] VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_687 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_337 VGND VPWR sky130_fd_sc_hd__decap_12
X_5729_ _5544_/X _5685_/X _5728_/X _5729_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_108_203 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_537 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_431 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_751 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_153 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_916 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_871 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_735 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_459 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_245 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_278 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_289 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_383 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_501 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_504 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_729 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_397 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_602 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_304 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_581 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_283 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_337 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_294 VGND VPWR sky130_fd_sc_hd__decap_12
X_4060_ _3973_/A _4060_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_98 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_540 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_724 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_768 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_716 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_407 VGND VPWR sky130_fd_sc_hd__decap_12
X_7750_ _3753_/Y _5125_/A _7750_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4962_ _4949_/X _5124_/B _4940_/X _4962_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_51_226 VGND VPWR sky130_fd_sc_hd__fill_1
X_3913_ _3892_/X _6359_/B _3912_/X _3913_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6701_ _6701_/A _6700_/X _6701_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_7681_ _4155_/Y _6851_/B _7684_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4893_ _4891_/X _4892_/Y _4882_/X _4894_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_3844_ _3834_/X _3843_/X _3825_/X _3845_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_6632_ _6623_/B _6506_/X _6619_/A _6590_/X _6633_/B VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_60_793 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_613 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_158 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_309 VGND VPWR sky130_fd_sc_hd__decap_8
X_6563_ _6559_/X _6560_/Y _6561_/X _6562_/Y _6565_/A VGND VPWR sky130_fd_sc_hd__a211o_4
X_3775_ _3756_/X _6097_/A _3770_/X _3776_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_20_668 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_320 VGND VPWR sky130_fd_sc_hd__decap_8
X_6494_ _6453_/X _3962_/X _6486_/C _6493_/X _6490_/X _6494_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_8_190 VGND VPWR sky130_fd_sc_hd__decap_12
X_5514_ _5479_/X _5514_/B _5514_/C _5517_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_146_898 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_504 VGND VPWR sky130_fd_sc_hd__fill_1
X_5445_ _5414_/C _5414_/D _5412_/C _5313_/X _5414_/X _5445_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_114_773 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_762 VGND VPWR sky130_fd_sc_hd__fill_1
X_7115_ _7126_/C _4271_/X _7104_/X _7106_/X _7115_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_5376_ _5372_/X _5373_/Y _5374_/X _5375_/Y _5376_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_141_592 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_112 VGND VPWR sky130_fd_sc_hd__fill_1
X_4327_ _4281_/A _4327_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4258_ _4264_/A conf_hcb[2] _4263_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7046_ _7079_/C _7045_/X _7094_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_47_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_489 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_882 VGND VPWR sky130_fd_sc_hd__decap_3
X_4189_ _4100_/A _4189_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_28_735 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_790 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_259 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_501 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_74 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_300 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_311 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_367 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_867 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_294 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_145 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_123 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_871 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_462 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_146_128 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_559 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_548 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_171 VGND VPWR sky130_fd_sc_hd__decap_12
X_5230_ _5244_/A _5169_/B _5195_/X south_double_out[1] _5230_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_143_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_570 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_710 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_112 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_101 VGND VPWR sky130_fd_sc_hd__fill_2
X_5161_ _5161_/A east_single_in[1] _5161_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4112_ _4111_/Y _6812_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_69_657 VGND VPWR sky130_fd_sc_hd__decap_12
X_5092_ _4886_/Y north_double_in[1] _4881_/Y _5092_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_4043_ _6672_/A _6658_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_110_286 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_521 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_370 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_874 VGND VPWR sky130_fd_sc_hd__decap_12
X_5994_ _7184_/A _5994_/B _5999_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_587 VGND VPWR sky130_fd_sc_hd__fill_1
X_7733_ _3845_/Y _6218_/B _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4945_ _4926_/X _4944_/Y _4940_/X _4946_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_7664_ _4257_/Y _4253_/A _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4876_ _4872_/A conf_sb[38] _4876_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_410 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_421 VGND VPWR sky130_fd_sc_hd__decap_12
X_6615_ _4013_/Y _6620_/B _6615_/C _6486_/D _6615_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3827_ _3827_/A _3827_/B _3827_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_119_810 VGND VPWR sky130_fd_sc_hd__decap_12
X_7595_ _4621_/Y _5460_/C _7592_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6546_ _3984_/A _6552_/D _6555_/A _6478_/X _6520_/X _6546_/X VGND VPWR sky130_fd_sc_hd__o32a_4
X_3758_ _3756_/X _5147_/A _3747_/X _3759_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_145_150 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_375 VGND VPWR sky130_fd_sc_hd__decap_8
X_6477_ _3955_/A _7713_/Q _6476_/Y _6470_/Y _6477_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_118_386 VGND VPWR sky130_fd_sc_hd__decap_8
X_3689_ _3793_/A _4959_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_133_367 VGND VPWR sky130_fd_sc_hd__decap_8
X_5428_ _5423_/X _5424_/X _5425_/X _5427_/Y _5428_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_58_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_5359_ _5359_/A _5359_/B _5354_/X _5359_/D _5359_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_101_231 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_454 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_798 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_787 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_476 VGND VPWR sky130_fd_sc_hd__decap_12
X_7029_ _7029_/A _7029_/B _7029_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_68_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_874 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_863 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_543 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_384 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_373 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_855 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_899 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_719 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_618 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_281 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_106 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_403 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_331 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_320 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_11 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_487 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_684 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_386 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_131 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_432 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_808 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_562 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_329 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_170 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_587 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_373 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_557 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_719 VGND VPWR sky130_fd_sc_hd__fill_1
X_4730_ _4729_/Y _4730_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_86 VGND VPWR sky130_fd_sc_hd__decap_12
X_4661_ _4654_/X _4660_/Y _4642_/X _4661_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6400_ _6400_/A _6400_/B _6419_/A _6601_/D _6400_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_128_640 VGND VPWR sky130_fd_sc_hd__fill_1
X_7380_ _7380_/A _7363_/A _7380_/C _7381_/D VGND VPWR sky130_fd_sc_hd__and3_4
X_6331_ _6330_/X _6359_/B _6320_/X _6322_/X _6365_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_127_150 VGND VPWR sky130_fd_sc_hd__decap_3
X_4592_ _5431_/A _5440_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_6_480 VGND VPWR sky130_fd_sc_hd__decap_12
X_6262_ _6283_/A _6261_/X _6309_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_6193_ _3847_/Y _6193_/B _6193_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_130_326 VGND VPWR sky130_fd_sc_hd__decap_8
X_5213_ _4503_/X _5165_/D _4522_/A _5194_/B _5213_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_5144_ _5144_/A north_clb_output[0] _5144_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_85_914 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_318 VGND VPWR sky130_fd_sc_hd__decap_12
X_5075_ _5075_/A _5075_/B _5075_/C _5075_/D _5075_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_57_649 VGND VPWR sky130_fd_sc_hd__decap_8
X_4026_ _4023_/Y _4026_/B _4026_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_53_855 VGND VPWR sky130_fd_sc_hd__decap_8
X_5977_ _6001_/B _5978_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_139_916 VGND VPWR sky130_fd_sc_hd__fill_2
X_7716_ _7716_/D _6381_/B _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_52_398 VGND VPWR sky130_fd_sc_hd__decap_8
X_4928_ _4926_/X _4927_/Y _4906_/X _4928_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_100_67 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_56 VGND VPWR sky130_fd_sc_hd__decap_8
X_7647_ _7647_/D _5221_/B _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_251 VGND VPWR sky130_fd_sc_hd__decap_12
X_4859_ _4809_/A _4859_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7578_ _7578_/D _4714_/A _7579_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_134_632 VGND VPWR sky130_fd_sc_hd__decap_8
X_6529_ _6550_/A _6528_/X _6529_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_106_301 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_142 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_849 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_304 VGND VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_5_20_0_clk clkbuf_5_21_0_clk/A _7706_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_0_645 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_479 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_608 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_513 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_568 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_527 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_426 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_273 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_413 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_638 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_405 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_800 VGND VPWR sky130_fd_sc_hd__fill_1
X_5900_ _5899_/X _5900_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6880_ _6876_/X _6877_/X _6878_/X _6879_/Y _6880_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_34_321 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_855 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_140 VGND VPWR sky130_fd_sc_hd__fill_1
X_5831_ _5857_/A _5831_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_61_184 VGND VPWR sky130_fd_sc_hd__decap_8
X_5762_ _5760_/B _5762_/B _5763_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_34_398 VGND VPWR sky130_fd_sc_hd__decap_8
X_7501_ clb_output[6] clb_output_west[0] VGND VPWR sky130_fd_sc_hd__buf_2
X_4713_ _4723_/A conf_vcb[21] _4713_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_147_245 VGND VPWR sky130_fd_sc_hd__decap_8
X_5693_ _5692_/X _5709_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_147_278 VGND VPWR sky130_fd_sc_hd__decap_3
X_7432_ _7432_/HI east_clb_input[8] VGND VPWR sky130_fd_sc_hd__conb_1
X_4644_ _4639_/Y _4643_/X _7591_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_632 VGND VPWR sky130_fd_sc_hd__decap_8
X_7363_ _7363_/A _7365_/A _7412_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_4575_ _4568_/X conf_vcb[46] _4575_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_6314_ _6314_/A _6314_/B clb_input[5] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_654 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_142 VGND VPWR sky130_fd_sc_hd__decap_3
X_7294_ _7293_/X _7295_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_143_473 VGND VPWR sky130_fd_sc_hd__decap_12
X_6245_ _6204_/Y _6245_/B _6245_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_104_838 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_635 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_348 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_6176_ _6179_/B _6175_/X _6179_/A _6122_/B _6176_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_111_381 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_733 VGND VPWR sky130_fd_sc_hd__decap_12
X_5127_ _5127_/A north_clb_output[0] _5127_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_85_777 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_232 VGND VPWR sky130_fd_sc_hd__fill_1
X_5058_ _5138_/B _6031_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_29_159 VGND VPWR sky130_fd_sc_hd__decap_12
X_4009_ _3950_/A _4017_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_55_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_652 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_663 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_313 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_357 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_757 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_738 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_602 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_56 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_560 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_690 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_593 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_486 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_497 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_446 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_799 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_788 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_287 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_235 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_449 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_855 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_343 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_685 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_836 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_70 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_520 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_267 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_407 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_542 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_3 clb_cout VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_144_215 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_4360_ _4350_/X _5123_/A _4341_/X _4361_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_140_421 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_495 VGND VPWR sky130_fd_sc_hd__fill_1
X_4291_ _4281_/X _5075_/A _4272_/X _4291_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_112_145 VGND VPWR sky130_fd_sc_hd__decap_8
X_6030_ _6030_/A _6030_/B _6030_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_86_508 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_189 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_733 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_703 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_468 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_585 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_276 VGND VPWR sky130_fd_sc_hd__fill_2
X_6932_ _6927_/A _4171_/X _6941_/C _6664_/D _6932_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_129 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_641 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_257 VGND VPWR sky130_fd_sc_hd__fill_2
X_6863_ _6863_/A _6864_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5814_ _5813_/Y _5814_/B east_clb_input[3] VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_22_324 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6794_ west_double_in[3] _6795_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_50_677 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_532 VGND VPWR sky130_fd_sc_hd__decap_12
X_5745_ _5739_/A _6642_/A _3723_/Y _5745_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_22_379 VGND VPWR sky130_fd_sc_hd__fill_1
X_5676_ _5672_/C _5700_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_136_727 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_204 VGND VPWR sky130_fd_sc_hd__decap_3
X_7415_ _7287_/A _7414_/B _7416_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_4627_ _4624_/X _4626_/X _4614_/X _4627_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_151_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_7346_ _5908_/X _7302_/X _7345_/X _7346_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_4558_ _4548_/A conf_vcb[49] _4558_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_116_495 VGND VPWR sky130_fd_sc_hd__fill_1
X_7277_ _4439_/X _6023_/X _7243_/X _7237_/A _7277_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_103_123 VGND VPWR sky130_fd_sc_hd__decap_12
X_4489_ _4486_/Y _4488_/X _7618_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_1_239 VGND VPWR sky130_fd_sc_hd__decap_4
X_6228_ _6218_/C _6193_/B _6228_/C _6228_/D _6228_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_131_454 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_44 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_487 VGND VPWR sky130_fd_sc_hd__fill_1
X_6159_ _6129_/A _6163_/D _6133_/X west_double_out[1] _6159_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_66_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_744 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_863 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_246 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_408 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_306 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_532 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_521 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_688 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_565 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_261 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_744 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_703 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_276 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_235 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_224 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_599 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_110 VGND VPWR sky130_fd_sc_hd__decap_12
X_3860_ _3860_/A _3859_/X _7730_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_3791_ _3787_/A conf_hcb[80] _3791_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_839 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_190 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5530_ _6034_/A _5813_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_8_361 VGND VPWR sky130_fd_sc_hd__decap_12
X_5461_ _5469_/C _5461_/B _5529_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_133_708 VGND VPWR sky130_fd_sc_hd__decap_12
X_4412_ _4411_/X _4412_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7200_ _7191_/C _4411_/X _7166_/X _4402_/X _7200_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_99_611 VGND VPWR sky130_fd_sc_hd__decap_8
X_5392_ _5392_/A _5393_/B _5394_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_125_270 VGND VPWR sky130_fd_sc_hd__fill_1
X_7131_ _7101_/A _7101_/B _7131_/C _7127_/B _7131_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_4343_ _4339_/Y _4343_/B _7646_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_4274_ _4268_/Y _4273_/X _7661_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_99_666 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_7062_ _4222_/A _7043_/A _7062_/C _7061_/Y _7062_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_113_498 VGND VPWR sky130_fd_sc_hd__decap_12
X_6013_ _5976_/A _5993_/B _5988_/C _5871_/X _6010_/X _6013_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_100_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_541 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_511 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_714 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_416 VGND VPWR sky130_fd_sc_hd__decap_8
X_6915_ _6915_/A _6915_/B _6916_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_70_706 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_600 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_460 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6846_ _6706_/A _6788_/X _6846_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_149_830 VGND VPWR sky130_fd_sc_hd__decap_12
X_6777_ _6710_/A _6776_/B _6778_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XPHY_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_463 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_340 VGND VPWR sky130_fd_sc_hd__decap_12
X_3989_ _6547_/B _3990_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_10_349 VGND VPWR sky130_fd_sc_hd__decap_12
X_5728_ _5728_/A _5728_/B _5728_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_5659_ _6023_/A _5659_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_117_771 VGND VPWR sky130_fd_sc_hd__decap_8
X_7329_ _4449_/X _7297_/A _7310_/X _7329_/D _7329_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_104_487 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_165 VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_13_0_clk clkbuf_3_6_0_clk/X clkbuf_5_27_0_clk/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_58_541 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_671 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_308 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_883 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_703 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_393 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_544 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_555 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_408 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_147 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_513 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_154_354 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_142_516 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_760 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_342 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_782 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_898 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_903 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_150_593 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_758 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_471 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_419 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_791 VGND VPWR sky130_fd_sc_hd__fill_2
X_4961_ _4961_/A _5124_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_3912_ _3854_/A _3912_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6700_ _6700_/A _6700_/B _6510_/C _6655_/A _6700_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_7680_ _4159_/Y _7680_/Q _7692_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_32_441 VGND VPWR sky130_fd_sc_hd__decap_12
X_4892_ _4892_/A _4892_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_51_249 VGND VPWR sky130_fd_sc_hd__fill_1
X_3843_ _6228_/D _3843_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_6631_ _4006_/A _6631_/B _6631_/C _6633_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_146_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_310 VGND VPWR sky130_fd_sc_hd__fill_1
X_6562_ _6558_/A _6536_/D _6550_/A _6497_/D _6562_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_3774_ _6089_/B _6097_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_9_670 VGND VPWR sky130_fd_sc_hd__fill_1
X_6493_ east_double_in[0] _6493_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_5513_ _5513_/A _5513_/B _5514_/C VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_145_365 VGND VPWR sky130_fd_sc_hd__fill_1
X_5444_ _5414_/X _5417_/Y _5444_/C _5444_/X VGND VPWR sky130_fd_sc_hd__or3_4
X_7114_ _7662_/Q _7126_/C VGND VPWR sky130_fd_sc_hd__buf_1
X_5375_ _5375_/A _5339_/A _5341_/A south_double_out[3] _5375_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_141_571 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_785 VGND VPWR sky130_fd_sc_hd__decap_4
X_4326_ _4344_/A conf_vcb[92] _4330_/A VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_113_295 VGND VPWR sky130_fd_sc_hd__decap_8
X_4257_ _4257_/A _4257_/B _4257_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_87_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_135 VGND VPWR sky130_fd_sc_hd__decap_12
X_7045_ _7053_/C _7079_/B _7045_/C _7045_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_86_179 VGND VPWR sky130_fd_sc_hd__fill_1
X_4188_ _4188_/A _4187_/X _7675_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_28_703 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_853 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_503 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_257 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_396 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_536 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_419 VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_2_0_clk clkbuf_3_3_0_clk/A clkbuf_3_2_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_42_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_7 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_547 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6829_ _6823_/X _6825_/Y _6826_/X _6828_/Y _6831_/A VGND VPWR sky130_fd_sc_hd__a211o_4
XPHY_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_794 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_117 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_855 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_546 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_505 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_398 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_323 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_741 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_240 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_879 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_379 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_785 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_262 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_102 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_883 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_360 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_371 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_544 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_374 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_536 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_588 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_800 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_321 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_603 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_722 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5160_ _5158_/A _5034_/A north_single_in[1] _5158_/X _5159_/X south_single_out[1]
+ VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_111_733 VGND VPWR sky130_fd_sc_hd__decap_4
X_4111_ _7688_/Q _4111_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_69_669 VGND VPWR sky130_fd_sc_hd__fill_2
X_5091_ _5091_/A _6663_/A _5091_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_4042_ _6670_/A _6672_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_56_308 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_500 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_276 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_499 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_842 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_382 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_661 VGND VPWR sky130_fd_sc_hd__decap_6
X_5993_ _5993_/A _5993_/B _6008_/A _7247_/D _5993_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_80_823 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_7732_ _3849_/Y _7732_/Q _7732_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_91_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_396 VGND VPWR sky130_fd_sc_hd__fill_1
X_4944_ _7533_/Q _4944_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7663_ _4263_/Y _7124_/B _7688_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_4875_ _4875_/A _4874_/X _7548_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_433 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_794 VGND VPWR sky130_fd_sc_hd__decap_4
X_6614_ _6614_/A _6619_/B _6619_/C _4020_/A _6614_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_3826_ _3805_/X _6179_/B _3825_/X _3827_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_119_822 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_800 VGND VPWR sky130_fd_sc_hd__fill_1
X_7594_ _7594_/D _7594_/Q _7571_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6545_ _3984_/A _6547_/B _6545_/C _6544_/Y _6545_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_119_855 VGND VPWR sky130_fd_sc_hd__decap_12
X_3757_ _7749_/Q _5147_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_134_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_145_162 VGND VPWR sky130_fd_sc_hd__decap_12
X_6476_ _6606_/A1 _6471_/Y _6475_/Y _6476_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
X_3688_ rst _3793_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5427_ _5423_/A _5427_/B _5433_/A _5571_/D _5427_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
XFILLER_133_379 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_571 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_560 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_838 VGND VPWR sky130_fd_sc_hd__decap_12
X_5358_ _5358_/A _5341_/A _5356_/X _5359_/D VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_102_755 VGND VPWR sky130_fd_sc_hd__decap_8
X_4309_ _4309_/A _4309_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_114_11 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_105 VGND VPWR sky130_fd_sc_hd__decap_6
X_7028_ _7028_/A _7028_/B _7029_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_5289_ _5289_/A _4544_/A _5289_/C _5289_/D _5289_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_114_44 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_59 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_566 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_672 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_588 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_32 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_333 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_366 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_772 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_58 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_415 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_293 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_74 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_354 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_23 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_151_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_696 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_152_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_574 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_466 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_628 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_606 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_447 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_425 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_661 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_650 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_599 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_856 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_845 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_208 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_764 VGND VPWR sky130_fd_sc_hd__decap_6
X_4660_ _7588_/Q _4660_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_9_98 VGND VPWR sky130_fd_sc_hd__decap_12
X_6330_ _6330_/A _6330_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_4591_ _5395_/C _5431_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_143_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_825 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_324 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_806 VGND VPWR sky130_fd_sc_hd__decap_12
X_6261_ _6261_/A _6261_/B _3858_/Y _6261_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_6_492 VGND VPWR sky130_fd_sc_hd__decap_8
X_6192_ _6192_/A _6191_/X _6250_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_5212_ _7645_/Q _5210_/Y _5211_/X _5212_/X VGND VPWR sky130_fd_sc_hd__o21a_4
X_5143_ _5144_/A clb_output[0] _5143_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_96_252 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_285 VGND VPWR sky130_fd_sc_hd__decap_12
X_5074_ _5075_/B _5070_/X _5071_/X _5072_/X _5073_/X _5074_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_56_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_831 VGND VPWR sky130_fd_sc_hd__decap_8
X_4025_ _4011_/X _6614_/A _4002_/X _4026_/B VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_65_672 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_363 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_886 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_642 VGND VPWR sky130_fd_sc_hd__fill_1
X_5976_ _5976_/A _5988_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7715_ _3948_/Y _6505_/A _7715_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_731 VGND VPWR sky130_fd_sc_hd__fill_1
X_4927_ _5149_/A _4927_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_4858_ _7551_/Q _4858_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_7646_ _7646_/D _5216_/A _7652_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_449 VGND VPWR sky130_fd_sc_hd__decap_8
X_3809_ _3805_/X _6129_/A _3794_/X _3809_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_20_263 VGND VPWR sky130_fd_sc_hd__decap_12
X_4789_ _4843_/A _4807_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_7577_ _7577_/D _7577_/Q _7574_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
X_6528_ _6525_/X _6536_/D _3977_/Y _6528_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_118_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_151 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_7 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_313 VGND VPWR sky130_fd_sc_hd__fill_1
X_6459_ _3966_/Y _6448_/B _6459_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_134_666 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_806 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_15 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_602 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_891 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_541 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_764 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_620 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_764 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_245 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_460 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_611 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_154 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_440 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_742 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_70 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_764 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_371 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_360 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_105 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_767 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_255 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_330 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_823 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_642 VGND VPWR sky130_fd_sc_hd__fill_2
X_5830_ _7570_/Q _5857_/A VGND VPWR sky130_fd_sc_hd__buf_1
X_5761_ _4741_/Y _7572_/Q _5762_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_148_703 VGND VPWR sky130_fd_sc_hd__decap_12
X_7500_ clb_output[5] clb_output_south[1] VGND VPWR sky130_fd_sc_hd__buf_2
X_4712_ _4712_/A _4712_/B _7579_/D VGND VPWR sky130_fd_sc_hd__nor2_4
X_7431_ _7431_/HI clb_output_west[7] VGND VPWR sky130_fd_sc_hd__conb_1
X_5692_ _4714_/A _5674_/B _5692_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_135_408 VGND VPWR sky130_fd_sc_hd__decap_12
X_4643_ _4624_/X _4640_/Y _4642_/X _4643_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7362_ _7370_/A _7370_/B _4470_/Y _7365_/A VGND VPWR sky130_fd_sc_hd__or3_4
X_4574_ _4569_/Y _4574_/B _4574_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_128_493 VGND VPWR sky130_fd_sc_hd__fill_1
X_6313_ _6251_/A _6312_/B _6314_/A VGND VPWR sky130_fd_sc_hd__nor2_4
X_7293_ _7625_/Q _7293_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_143_485 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_463 VGND VPWR sky130_fd_sc_hd__fill_1
X_6244_ _6244_/A _6244_/B _6245_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_115_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_647 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_113 VGND VPWR sky130_fd_sc_hd__decap_3
X_6175_ _6174_/Y _6175_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_112_861 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_371 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_745 VGND VPWR sky130_fd_sc_hd__decap_12
X_5126_ _5127_/A clb_output[0] _5126_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_69_296 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_255 VGND VPWR sky130_fd_sc_hd__decap_12
X_5057_ clb_output[2] _5138_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_45_609 VGND VPWR sky130_fd_sc_hd__fill_1
X_4008_ _4008_/A _4008_/B _4008_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_85_789 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_417 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_406 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_812 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_683 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_620 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_694 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_517 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_889 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_472 VGND VPWR sky130_fd_sc_hd__decap_12
X_5959_ vertical_global[1] _7215_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_528 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_325 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_224 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_550 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_769 VGND VPWR sky130_fd_sc_hd__decap_12
X_7629_ _7629_/D _7629_/Q _7629_/CLK VGND VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_441 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_474 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_614 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_68 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_572 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_672 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_247 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_480 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_300 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_889 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_697 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_572 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_279 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_419 VGND VPWR sky130_fd_sc_hd__decap_8
XANTENNA_4 clb_input_south[3] VGND VPWR sky130_fd_sc_hd__diode_2
XFILLER_137_290 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_153_794 VGND VPWR sky130_fd_sc_hd__decap_12
X_4290_ _4290_/A _5075_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_3_281 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_157 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_550 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_520 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_6931_ _6931_/A _6941_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_81_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_631 VGND VPWR sky130_fd_sc_hd__fill_1
X_6862_ _6860_/B _6862_/B _6863_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_34_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_653 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_472 VGND VPWR sky130_fd_sc_hd__decap_12
X_5813_ _5813_/A _5812_/B _5813_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_23_826 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_837 VGND VPWR sky130_fd_sc_hd__decap_12
X_6793_ _6793_/A _6793_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_23_859 VGND VPWR sky130_fd_sc_hd__decap_12
X_5744_ _5744_/A _6642_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_148_544 VGND VPWR sky130_fd_sc_hd__decap_12
X_5675_ _5675_/A _5716_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_136_739 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_7414_ _7413_/X _7414_/B _7416_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_4626_ _4625_/Y _4626_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_7345_ _7345_/A _7344_/X _7345_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_131_400 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_614 VGND VPWR sky130_fd_sc_hd__decap_12
X_4557_ _4557_/A _4557_/B _4557_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_104_647 VGND VPWR sky130_fd_sc_hd__decap_12
X_7276_ _4416_/A _7276_/B _7275_/X _7276_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_89_314 VGND VPWR sky130_fd_sc_hd__decap_8
X_4488_ _4481_/X _7364_/A _4471_/X _4488_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_6227_ _6228_/C _3843_/X _6226_/Y west_double_out[0] _6223_/X _6227_/Y VGND VPWR
+ sky130_fd_sc_hd__a32oi_4
XFILLER_104_669 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_135 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_499 VGND VPWR sky130_fd_sc_hd__decap_8
X_6158_ _6179_/A _3823_/X _6163_/C _6158_/D _6158_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_66_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_5109_ _5106_/A north_double_in[3] _4309_/Y _5109_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_58_756 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_886 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_875 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_726 VGND VPWR sky130_fd_sc_hd__decap_3
X_6089_ _6098_/A _6089_/B clb_output[1] _6089_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_122_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_737 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_480 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_428 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_258 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_642 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_792 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_837 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_318 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_544 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_147_74 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_794 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_433 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_764 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_466 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_807 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_306 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_509 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_741 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_680 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_273 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_715 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_288 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_141 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_450 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_781 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_910 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_656 VGND VPWR sky130_fd_sc_hd__decap_12
X_3790_ _3790_/A _3789_/X _7742_/D VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_20_829 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_706 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_191 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_830 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_373 VGND VPWR sky130_fd_sc_hd__decap_12
X_5460_ _7593_/Q _7592_/Q _5460_/C _4625_/Y _5461_/B VGND VPWR sky130_fd_sc_hd__or4_4
X_4411_ _7181_/B _4411_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_68_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_5391_ _5390_/Y _5389_/X _5392_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_141_720 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_282 VGND VPWR sky130_fd_sc_hd__decap_3
X_7130_ _7132_/A _7132_/B _7132_/C _6348_/A _7126_/X _7130_/Y VGND VPWR sky130_fd_sc_hd__a32oi_4
XFILLER_98_100 VGND VPWR sky130_fd_sc_hd__decap_12
X_4342_ _4327_/X _5218_/A _4341_/X _4343_/B VGND VPWR sky130_fd_sc_hd__a21o_4
X_4273_ _4252_/X _4271_/X _4272_/X _4273_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_7061_ _7061_/A1 _7058_/Y _7060_/Y _7061_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_4_590 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_285 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_166 VGND VPWR sky130_fd_sc_hd__decap_3
X_6012_ _6007_/X _6009_/Y _6010_/X _6011_/Y _6012_/X VGND VPWR sky130_fd_sc_hd__a211o_4
.ends
